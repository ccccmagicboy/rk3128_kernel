# 1 "arch/arm/boot/dts/rk3188-tb.dts"
# 1 "<built-in>"
# 1 "<command-line>"
# 1 "arch/arm/boot/dts/rk3188-tb.dts"
/dts-v1/;

# 1 "arch/arm/boot/dts/rk3188.dtsi" 1
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/clock/ddr.h" 1
# 2 "arch/arm/boot/dts/rk3188.dtsi" 2
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/rkfb/rk_fb.h" 1
# 3 "arch/arm/boot/dts/rk3188.dtsi" 2
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/suspend/rockchip-pm.h" 1
# 4 "arch/arm/boot/dts/rk3188.dtsi" 2
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/sensor-dev.h" 1
# 5 "arch/arm/boot/dts/rk3188.dtsi" 2

# 1 "arch/arm/boot/dts/skeleton.dtsi" 1






/ {
 #address-cells = <1>;
 #size-cells = <1>;
 chosen { };
 aliases { };
 memory { device_type = "memory"; reg = <0 0>; };
};
# 7 "arch/arm/boot/dts/rk3188.dtsi" 2
# 1 "arch/arm/boot/dts/rk3188-pinctrl.dtsi" 1
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/interrupt-controller/arm-gic.h" 1







# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/interrupt-controller/irq.h" 1
# 9 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/interrupt-controller/arm-gic.h" 2
# 2 "arch/arm/boot/dts/rk3188-pinctrl.dtsi" 2
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/gpio/gpio.h" 1
# 3 "arch/arm/boot/dts/rk3188-pinctrl.dtsi" 2
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/pinctrl/rockchip.h" 1
# 4 "arch/arm/boot/dts/rk3188-pinctrl.dtsi" 2
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/pinctrl/rockchip-rk3188.h" 1
# 5 "arch/arm/boot/dts/rk3188-pinctrl.dtsi" 2

/ {
 pinctrl: pinctrl@20008000 {
  compatible = "rockchip,rk3188-pinctrl";
  reg = <0x20008000 0x60>,
        <0x20008060 0x40>,
        <0x20008164 0x40>,
        <0x200080f4 0x10>;
  reg-names = "base", "mux", "pull", "drv";
  #address-cells = <1>;
  #size-cells = <1>;
  ranges;

  gpio0: gpio0@0x2000a000 {
   compatible = "rockchip,rk3188-gpio-bank0";
   reg = <0x2000a000 0x100>,
         <0x20004064 0x8>;
   reg-names = "base", "pull_bank0";
   interrupts = <0 54 4>;
   clocks = <&clk_gates8 9>;

   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpio1: gpio1@0x2003c000 {
   compatible = "rockchip,gpio-bank";
   reg = <0x2003c000 0x100>;
   interrupts = <0 55 4>;
   clocks = <&clk_gates8 10>;

   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpio2: gpio2@2003e000 {
   compatible = "rockchip,gpio-bank";
   reg = <0x2003e000 0x100>;
   interrupts = <0 56 4>;
   clocks = <&clk_gates8 11>;

   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpio3: gpio3@20080000 {
   compatible = "rockchip,gpio-bank";
   reg = <0x20080000 0x100>;
   interrupts = <0 57 4>;
   clocks = <&clk_gates8 12>;

   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpio15: gpio15@20082000 {
   compatible = "rockchip,gpio-bank";
   reg = <0x20082000 0x100>;
   interrupts = <0 127 4>;
   clocks = <&clk_gates8 12>;

   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  pcfg_pull_up: pcfg_pull_up {
   bias-pull-up;
  };

  pcfg_pull_down: pcfg_pull_down {
   bias-pull-down;
  };

  pcfg_pull_none: pcfg_pull_none {
   bias-disable;
  };

  gpio1_uart0 {
   uart0_xfer: uart0-xfer {
    rockchip,pins = <0x1a01>,
      <0x1a11>;
    rockchip,pull = <4>;
    rockchip,voltage = <0>;
    rockchip,drive = <0>;

   };

   uart0_cts: uart0-cts {
    rockchip,pins = <0x1a21>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   uart0_rts: uart0-rts {
    rockchip,pins = <0x1a31>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   uart0_rts_gpio: uart0-rts-gpio {
    rockchip,pins = <((0x1a31) & 0xfff0)>;
    rockchip,drive = <0>;
   };
  };

  gpio1_uart1 {
   uart1_xfer: uart1-xfer {
    rockchip,pins = <0x1a41>,
      <0x1a51>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   uart1_cts: uart1-cts {
    rockchip,pins = <0x1a61>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   uart1_rts: uart1-rts {
    rockchip,pins = <0x1a71>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   uart1_rts_gpio: uart1-rts-gpio {
    rockchip,pins = <((0x1a71) & 0xfff0)>;
    rockchip,drive = <0>;
   };
  };

  gpio1_uart2 {
   uart2_xfer: uart2-xfer {
    rockchip,pins = <0x1b01>,
      <0x1b11>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

  };

  gpio1_uart3 {
   uart3_xfer: uart3-xfer {
    rockchip,pins = <0x1b21>,
      <0x1b31>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   uart3_cts: uart3-cts {
    rockchip,pins = <0x1b41>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   uart3_rts: uart3-rts {
    rockchip,pins = <0x1b51>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   uart3_rts_gpio: uart3-rts-gpio {
    rockchip,pins = <((0x1b51) & 0xfff0)>;
    rockchip,drive = <0>;
   };
  };

  gpio1_i2c0 {
   i2c0_sda:i2c0-sda {
    rockchip,pins = <0x1d01>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   i2c0_scl:i2c0-scl {
    rockchip,pins = <0x1d11>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   i2c0_gpio: i2c0-gpio {
    rockchip,pins = <((0x1d01) & 0xfff0)>, <((0x1d11) & 0xfff0)>;
    rockchip,drive = <0>;
   };
  };

  gpio1_i2c1 {
   i2c1_sda:i2c1-sda {
    rockchip,pins = <0x1d21>;
    rockchip,pull = <4>;
    rockchip,voltage = <0>;
    rockchip,drive = <0>;

   };

   i2c1_scl:i2c1-scl {
    rockchip,pins = <0x1d31>;
    rockchip,pull = <4>;
    rockchip,voltage = <0>;
    rockchip,drive = <0>;

   };

   i2c1_gpio: i2c1-gpio {
    rockchip,pins = <((0x1d21) & 0xfff0)>, <((0x1d31) & 0xfff0)>;
    rockchip,drive = <0>;
   };
  };

  gpio1_i2c2 {
   i2c2_sda:i2c2-sda {
    rockchip,pins = <0x1d41>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   i2c2_scl:i2c2-scl {
    rockchip,pins = <0x1d51>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   i2c2_gpio: i2c2-gpio {
    rockchip,pins = <((0x1d41) & 0xfff0)>, <((0x1d51) & 0xfff0)>;
    rockchip,drive = <0>;
   };
  };

  gpio3_i2c3 {
   i2c3_sda:i2c3-sda {
    rockchip,pins = <0x3b62>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   i2c3_scl:i2c3-scl {
    rockchip,pins = <0x3b72>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   i2c3_gpio: i2c3-gpio {
    rockchip,pins = <((0x3b62) & 0xfff0)>, <((0x3b72) & 0xfff0)>;
    rockchip,drive = <0>;
   };
  };

  gpio1_i2c4 {
   i2c4_sda:i2c4-sda {
    rockchip,pins = <0x1d61>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   i2c4_scl:i2c4-scl {
    rockchip,pins = <0x1d71>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   i2c4_gpio: i2c4-gpio {
    rockchip,pins = <((0x1d61) & 0xfff0)>, <((0x1d71) & 0xfff0)>;
    rockchip,drive = <0>;
   };
  };

  gpio1_spi0 {
   spi0_txd:spi0-txd {
    rockchip,pins = <0x1a52>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   spi0_rxd:spi0-rxd {
    rockchip,pins = <0x1a42>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   spi0_clk:spi0-clk {
    rockchip,pins = <0x1a62>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   spi0_cs0:spi0-cs0 {
    rockchip,pins = <0x1a72>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   spi0_cs1:spi0-cs1 {
    rockchip,pins = <0x1b71>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

  };

  gpio1_spi1 {
   spi1_txd:spi1-txd {
    rockchip,pins = <0x0d51>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   spi1_rxd:spi1-rxd {
    rockchip,pins = <0x0d41>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   spi1_clk:spi1-clk {
    rockchip,pins = <0x0d61>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   spi1_cs0:spi1-cs0 {
    rockchip,pins = <0x0d71>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   spi1_cs1:spi1-cs1 {
    rockchip,pins = <0x1b62>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

  };

  gpio1_i2s0 {

   i2s0_mclk:i2s0-mclk {
    rockchip,pins = <0x1c01>;
    rockchip,pull = <4>;

    rockchip,drive = <2>;


   };

   i2s0_sclk:i2s0-sclk {
    rockchip,pins = <0x1c11>;
    rockchip,pull = <4>;

    rockchip,drive = <2>;


   };

   i2s0_lrckrx:i2s0-lrckrx {
    rockchip,pins = <0x1c21>;
    rockchip,pull = <4>;

    rockchip,drive = <2>;


   };

   i2s0_lrcktx:i2s0-lrcktx {
    rockchip,pins = <0x1c31>;
    rockchip,pull = <4>;

    rockchip,drive = <2>;


   };

   i2s0_sdo:i2s0-sdo {
    rockchip,pins = <0x1c51>;
    rockchip,pull = <4>;

    rockchip,drive = <2>;


   };

   i2s0_sdi:i2s0-sdi {
    rockchip,pins = <0x1c41>;
    rockchip,pull = <4>;

    rockchip,drive = <2>;


   };

   i2s0_gpio: i2s0-gpio {
    rockchip,pins = <((0x1c01) & 0xfff0)>,
      <((0x1c11) & 0xfff0)>,
      <((0x1c21) & 0xfff0)>,
      <((0x1c31) & 0xfff0)>,
      <((0x1c51) & 0xfff0)>,
      <((0x1c41) & 0xfff0)>;
    rockchip,drive = <2>;
   };
  };

  gpio2_lcdc1 {
   lcdc1_lcdc:lcdc1-lcdc {
    rockchip,pins = <0x2a01>,
      <0x2a11>,
      <0x2a21>,
      <0x2a31>,
      <0x2a41>,
      <0x2a51>,
      <0x2a61>,
      <0x2a71>,
      <0x2b01>,
      <0x2b11>,
      <0x2b21>,
      <0x2b31>,
      <0x2b41>,
      <0x2b51>,
      <0x2b61>,
      <0x2b71>,
      <0x2c01>,
      <0x2c11>,
      <0x2c21>,
      <0x2c31>,
      <0x2c41>,
      <0x2c51>,
      <0x2c61>,
      <0x2c71>,
      <0x2d01>,
      <0x2d11>,
      <0x2d21>,
      <0x2d31>;
    rockchip,pull = <4>;
    rockchip,drive = <0>;
   };

   lcdc1_gpio:lcdc1-gpio {
    rockchip,pins = <((0x2a01) & 0xfff0)>,
                                                <((0x2a11) & 0xfff0)>,
                                                <((0x2a21) & 0xfff0)>,
                                                <((0x2a31) & 0xfff0)>,
                                                <((0x2a41) & 0xfff0)>,
                                                <((0x2a51) & 0xfff0)>,
                                                <((0x2a61) & 0xfff0)>,
                                                <((0x2a71) & 0xfff0)>,
                                                <((0x2b01) & 0xfff0)>,
                                                <((0x2b11) & 0xfff0)>,
                                                <((0x2b21) & 0xfff0)>,
                                                <((0x2b31) & 0xfff0)>,
                                                <((0x2b41) & 0xfff0)>,
                                                <((0x2b51) & 0xfff0)>,
                                                <((0x2b61) & 0xfff0)>,
                                                <((0x2b71) & 0xfff0)>,
                                                <((0x2c01) & 0xfff0)>,
                                                <((0x2c11) & 0xfff0)>,
                                                <((0x2c21) & 0xfff0)>,
                                                <((0x2c31) & 0xfff0)>,
                                                <((0x2c41) & 0xfff0)>,
                                                <((0x2c51) & 0xfff0)>,
                                                <((0x2c61) & 0xfff0)>,
                                                <((0x2c71) & 0xfff0)>,
                                                <((0x2d01) & 0xfff0)>,
                                                <((0x2d11) & 0xfff0)>,
                                                <((0x2d21) & 0xfff0)>,
                                                <((0x2d31) & 0xfff0)>;
                                rockchip,pull = <4>;
                                rockchip,drive = <0>;

   };

  };

  gpio1_spdif {
   spdif_tx: spdif-tx {
    rockchip,pins = <0x1b61>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;


   };
  };

  gpio3_pwm {
   pwm0_pin:pwm0 {
    rockchip,pins = <0x3d31>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;


   };


   pwm1_pin:pwm1 {
    rockchip,pins = <0x3d41>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };


   pwm2_pin:pwm2 {
    rockchip,pins = <0x3d51>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };


   pwm3_pin:pwm3 {
    rockchip,pins = <0x3d61>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

  };


  gpio3_sdio {
   sd0_clk: sd0-clk {
    rockchip,pins = <0x3a21>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   sd0_cmd: sd0-cmd {
    rockchip,pins = <0x3a31>;
    rockchip,pull = <1>;

    rockchip,drive = <0>;

   };

   sd0_cd: sd0-cd {
    rockchip,pins = <0x3b01>;
    rockchip,pull = <1>;

    rockchip,drive = <0>;

   };

   sd0_cd_gpio:sd0_cd_gpio{
    rockchip,pins = <((0x3b01) & 0xfff0)>;
    rockchip,pull = <4>;
    rockchip,drive = <0>;
   };

   sd0_wp: sd0-wp {
    rockchip,pins = <0x3b11>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   sd0_pwr: sd0-pwr {
    rockchip,pins = <0x3a11>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   sd0_bus1: sd0-bus-width1 {
    rockchip,pins = <0x3a41>;
    rockchip,pull = <1>;

    rockchip,drive = <0>;

   };

   sd0_bus4: sd0-bus-width4 {
    rockchip,pins = <0x3a41>,
      <0x3a51>,
      <0x3a61 >,
      <0x3a71>;
    rockchip,pull = <1>;

    rockchip,drive = <0>;

   };
  };

  gpio3_sdmmc {
   sd1_clk: sd1-clk {
    rockchip,pins = <0x3c51>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   sd1_cmd: sd1-cmd {
    rockchip,pins = <0x3c01>;
    rockchip,pull = <1>;

    rockchip,drive = <0>;

   };

   sd1_cd: sd1-cd {
    rockchip,pins = <0x3c61>;
    rockchip,pull = <1>;

    rockchip,drive = <0>;

   };

   sd1_wp: sd1-wp {
    rockchip,pins = <0x3c71>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   sd1_bus1: sd1-bus-width1 {
    rockchip,pins = <0x3c11>;
    rockchip,pull = <1>;

    rockchip,drive = <0>;

   };

   sd1_bus4: sd1-bus-width4 {
    rockchip,pins = <0x3c11>,
      <0x3c21>,
      <0x3c31>,
      <0x3c41>;
    rockchip,pull = <1>;

    rockchip,drive = <0>;

   };
  };

  gpio3_rmii {
   rmii_clkoutpin: rmii-clkoutpin {
    rockchip,pins = <0x3c52>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   rmii_clkinpin: rmii-clkinpin {
    rockchip,pins = <0x3c52>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   rmii_txpins: rmii-txpins {
    rockchip,pins = <0x3c02>, <0x3c12>, <0x3c22>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   rmii_rxpins: rmii-rxpins {
    rockchip,pins = <0x3c32>, <0x3c42>, <0x3c62>, <0x3c72>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };

   rmii_mdpins: rmii-mdpins {
    rockchip,pins = <0x3d02>, <0x3d12>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;

   };
  };

  gpio1_gps {
   gps_mag:gps-mag {
    rockchip,pins = <0x1b22>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;


   };

   gps_sig:gps-sig {
    rockchip,pins = <0x1b32>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;


   };


   gps_rfclk:gps-rfclk {
    rockchip,pins = <0x1b42>;
    rockchip,pull = <4>;

    rockchip,drive = <0>;


   };

  };

  vol_domain {
   ap0_vcc:ap0-vcc {
    rockchip,pins = <0xfA00>;
    rockchip,voltage = <0>;
   };

   ap1_vcc:ap1-vcc {
    rockchip,pins = <0xfA10>;
    rockchip,voltage = <0>;
   };

   cif_vcc:cif-vcc {
    rockchip,pins = <0xfA20>;
    rockchip,voltage = <0>;
   };

   flash_vcc:flash-vcc {
    rockchip,pins = <0xfA30>;
    rockchip,voltage = <0>;
   };

   vccio0_vcc:vccio0-vcc {
    rockchip,pins = <0xfA40>;
    rockchip,voltage = <0>;
   };

   vccio1_vcc:vccio1-vcc {
    rockchip,pins = <0xfA50>;
    rockchip,voltage = <0>;
   };

   lcdc0_vcc:lcdc0-vcc {
    rockchip,pins = <0xfA60>;
    rockchip,voltage = <0>;
   };

   lcdc1_vcc:lcdc1-vcc {
    rockchip,pins = <0xfA70>;
    rockchip,voltage = <0>;
   };



   ap0_vcc_18:ap0-vcc-18 {
    rockchip,pins = <0xfA00>;
    rockchip,voltage = <1>;
   };

   ap1_vcc_18:ap1-vcc-18 {
    rockchip,pins = <0xfA10>;
    rockchip,voltage = <1>;
   };

   cif_vcc_18:cif-vcc-18 {
    rockchip,pins = <0xfA20>;
    rockchip,voltage = <1>;
   };

   flash_vcc_18:flash-vcc-18 {
    rockchip,pins = <0xfA30>;
    rockchip,voltage = <1>;
   };

   vccio0_vcc_18:vccio0-vcc-18 {
    rockchip,pins = <0xfA40>;
    rockchip,voltage = <1>;
   };

   vccio1_vcc_18:vccio1-vcc-18 {
    rockchip,pins = <0xfA50>;
    rockchip,voltage = <1>;
   };

   lcdc0_vcc_18:lcdc0-vcc-18 {
    rockchip,pins = <0xfA60>;
    rockchip,voltage = <1>;
   };

   lcdc1_vcc_18:lcdc1-vcc-18 {
    rockchip,pins = <0xfA70>;
    rockchip,voltage = <1>;
   };



   ap0_vcc_33:ap0-vcc-33 {
    rockchip,pins = <0xfA00>;
    rockchip,voltage = <0>;
   };

   ap1_vcc_33:ap1-vcc-33 {
    rockchip,pins = <0xfA10>;
    rockchip,voltage = <0>;
   };

   cif_vcc_33:cif-vcc-33 {
    rockchip,pins = <0xfA20>;
    rockchip,voltage = <0>;
   };

   flash_vcc_33:flash-vcc-33 {
    rockchip,pins = <0xfA30>;
    rockchip,voltage = <0>;
   };

   vccio0_vcc_33:vccio0-vcc-33 {
    rockchip,pins = <0xfA40>;
    rockchip,voltage = <0>;
   };

   vccio1_vcc_33:vccio1-vcc-33 {
    rockchip,pins = <0xfA50>;
    rockchip,voltage = <0>;
   };

   lcdc0_vcc_33:lcdc0-vcc-33 {
    rockchip,pins = <0xfA60>;
    rockchip,voltage = <0>;
   };

   lcdc1_vcc_33:lcdc1-vcc-33 {
    rockchip,pins = <0xfA70>;
    rockchip,voltage = <0>;
   };


  };


 };
};
# 8 "arch/arm/boot/dts/rk3188.dtsi" 2
# 1 "arch/arm/boot/dts/rk3188-clocks.dtsi" 1
# 15 "arch/arm/boot/dts/rk3188-clocks.dtsi"
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/clock/rockchip,rk3188.h" 1



# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/clock/rockchip.h" 1
# 5 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/clock/rockchip,rk3188.h" 2
# 16 "arch/arm/boot/dts/rk3188-clocks.dtsi" 2

/{
 clocks {
  compatible = "rockchip,rk-clocks";
  #address-cells = <1>;
  #size-cells = <1>;
  ranges = <0x0 0x20000000 0x0100>;

  fixed_rate_cons {
   compatible = "rockchip,rk-fixed-rate-cons";

   xin24m: xin24m {
    compatible = "fixed-clock";
    #clock-cells = <0>;
    clock-output-names = "xin24m";
    clock-frequency = <24000000>;
   };

   xin12m: xin12m {
    compatible = "fixed-clock";
    #clock-cells = <0>;
    clocks = <&xin24m>;
    clock-output-names = "xin12m";
    clock-frequency = <12000000>;
   };

   dummy: dummy {
    compatible = "fixed-clock";
    #clock-cells = <0>;
    clock-output-names = "dummy";
    clock-frequency = <0>;
   };


   rmii_clkin: rmii_clkin {
    compatible = "fixed-clock";
    #clock-cells = <0>;
    clock-output-names = "rmii_clkin";
    clock-frequency = <0>;
   };

   clk_hsadc_ext: clk_hsadc_ext {
    compatible = "fixed-clock";
    #clock-cells = <0>;
    clock-output-names = "clk_hsadc_ext";
    clock-frequency = <0>;
   };

   clk_cif_in: clk_cif_in {
    compatible = "fixed-clock";
    #clock-cells = <0>;
    clock-output-names = "clk_cif_in";
    clock-frequency = <0>;
   };

  };

  fixed_factor_cons {
   compatible = "rockchip,rk-fixed-factor-cons";

   otgphy0_480m: otgphy0_480m {
    compatible = "fixed-factor-clock";
    clocks = <&clk_gates1 5>;
    clock-output-names = "otgphy0_480m";
    clock-div = <1>;
    clock-mult = <20>;
    #clock-cells = <0>;
   };

   otgphy1_480m: otgphy1_480m {
    compatible = "fixed-factor-clock";
    clocks = <&clk_gates1 6>;
    clock-output-names = "otgphy1_480m";
    clock-div = <1>;
    clock-mult = <20>;
    #clock-cells = <0>;
   };

  };

  clock_regs {
   compatible = "rockchip,rk-clock-regs";
   reg = <0x0000 0x3ff>;
   #address-cells = <1>;
   #size-cells = <1>;
   ranges;


   pll_cons {
    compatible = "rockchip,rk-pll-cons";
    #address-cells = <1>;
    #size-cells = <1>;
    ranges ;

    clk_apll: pll-clk@0000 {
     compatible = "rockchip,rk3188-pll-clk";
     reg = <0x0000 0x10>;
     mode-reg = <0x0040 0>;
     status-reg = <0x00ac 6>;
     clocks = <&xin24m>;
     clock-output-names = "clk_apll";
     rockchip,pll-type = <(1 << (1))>;
     #clock-cells = <0>;
    };

    clk_dpll: pll-clk@0010 {
     compatible = "rockchip,rk3188-pll-clk";
     reg = <0x0010 0x10>;
     mode-reg = <0x0040 4>;
     status-reg = <0x00ac 5>;
     clocks = <&xin24m>;
     clock-output-names = "clk_dpll";
     rockchip,pll-type = <(1 << (0))>;
     #clock-cells = <0>;
    };

    clk_cpll: pll-clk@0020 {
     compatible = "rockchip,rk3188-pll-clk";
     reg = <0x0020 0x10>;
     mode-reg = <0x0040 8>;
     status-reg = <0x00ac 7>;
     clocks = <&xin24m>;
     clock-output-names = "clk_cpll";
     rockchip,pll-type = <(1 << (0))>;
     #clock-cells = <0>;
     #clock-init-cells = <1>;
    };

    clk_gpll: pll-clk@0030 {
     compatible = "rockchip,rk3188-pll-clk";
     reg = <0x0030 0x10>;
     mode-reg = <0x0040 12>;
     status-reg = <0x00ac 8>;
     clocks = <&xin24m>;
     clock-output-names = "clk_gpll";
     rockchip,pll-type = <(1 << (0))>;
     #clock-cells = <0>;
     #clock-init-cells = <1>;
    };
   };


   clk_sel_cons {
    compatible = "rockchip,rk-sel-cons";
    #address-cells = <1>;
    #size-cells = <1>;
    ranges;

    clk_sel_con0: sel-con@0044 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0044 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     aclk_cpu_div: aclk_cpu_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 5>;
      clocks = <&aclk_cpu>;
      clock-output-names = "aclk_cpu";
      #clock-cells = <0>;
      rockchip,div-type = <(0)>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };

     aclk_cpu: aclk_cpu_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <5 1>;
      clocks = <&clk_apll>, <&clk_gpll>;
      clock-output-names = "aclk_cpu";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     clk_core_peri: clk_core_peri_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <6 2>;
      clocks = <&clk_core>;
      clock-output-names = "clk_core_peri";
      rockchip,div-type = <(1 << (7))>;
      rockchip,clkops-idx = <12>;
      #clock-cells = <0>;
      rockchip,div-relations = <0x0 2
         0x1 4
         0x2 8
         0x3 16>;
     };

     clk_core: clk_core_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 1>;
      clocks = <&clk_apll>,
             <&clk_gates0 1>;
      clock-output-names = "clk_core";
      rockchip,flags = <((1 << (6)) |
         (1 << (7)))>;
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     clk_core_div: clk_core_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <9 5>;
      clocks = <&clk_core>;
      clock-output-names = "clk_core";
      rockchip,div-type = <(0)>;
      rockchip,clkops-idx = <11>;
      #clock-cells = <0>;
     };



    };

    clk_sel_con1: sel-con@0048 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0048 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;



     aclk_core: aclk_core_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <3 3>;
      clocks = <&clk_core>;
      clock-output-names = "aclk_core";
      #clock-cells = <0>;
      rockchip,div-type = <(1 << (7))>;
      rockchip,clkops-idx = <12>;
      rockchip,div-relations = <0x0 1
         0x1 2
         0x2 3
         0x3 4
         0x4 8>;
     };



     hclk_cpu: hclk_cpu_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 2>;
      clocks = <&aclk_cpu>;
      rockchip,div-type = <(1 << (1))>;
      clock-output-names = "hclk_cpu";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };



     pclk_cpu: pclk_cpu_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <12 2>;
      clocks = <&aclk_cpu>;
      rockchip,div-type = <(1 << (1))>;
      clock-output-names = "pclk_cpu";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     pclk_ahb2apb: pclk_ahb2apb_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <14 2>;
      clocks = <&hclk_cpu>;
      rockchip,div-type = <(1 << (1))>;
      clock-output-names = "pclk_ahb2apb";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

    };
    clk_sel_con2: sel-con@004c {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x004c 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;



     clk_i2s_pll_mux: clk_i2s_pll_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <15 1>;
      clocks = <&clk_gpll>, <&clk_cpll>;
      clock-output-names = "clk_i2s_pll";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };
    };

    clk_sel_con3: sel-con@0050 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0050 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_i2s_div: clk_i2s_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&clk_i2s_pll_mux>;
      rockchip,div-type = <(0)>;
      clock-output-names = "clk_i2s_div";
      #clock-cells = <0>;
     };



     clk_i2s: clk_i2s_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 2>;
      clocks = <&clk_i2s_div>, <&clk_i2s_frac>, <&xin12m>;
      clock-output-names = "clk_i2s";
      rockchip,clkops-idx = <6>;
      rockchip,flags = <(1 << (2))>;
      #clock-cells = <0>;
     };


    };



    clk_sel_con5: sel-con@0058 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0058 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_spdif_div: clk_spdif_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&clk_i2s_pll_mux>;
      rockchip,div-type = <(0)>;
      clock-output-names = "clk_spdif_div";

      #clock-cells = <0>;
     };



     clk_spdif: clk_spdif_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 2>;
      clocks = <&clk_spdif_div>, <&clk_spdif_frac>, <&xin12m>;
      clock-output-names = "clk_spdif";
      rockchip,clkops-idx = <6>;
      rockchip,flags = <(1 << (2))>;
      #clock-cells = <0>;
     };


    };



    clk_sel_con7: sel-con@0060 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0060 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;
     clk_i2s_frac: clk_i2s_frac {
      compatible = "rockchip,rk3188-frac-con";
      clocks = <&clk_i2s_div>;
      clock-output-names = "clk_i2s_frac";

      rockchip,bits = <0 32>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <4>;
     };
    };



    clk_sel_con9: sel-con@0068 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0068 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;
     clk_spdif_frac: clk_spdif_frac {
      compatible = "rockchip,rk3188-frac-con";
      clocks = <&clk_spdif_div>;
      clock-output-names = "clk_spdif_frac";

      rockchip,bits = <0 32>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <4>;
     };
    };

    clk_sel_con10: sel-con@006c {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x006c 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     aclk_peri_div: aclk_peri_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 5>;
      clocks = <&aclk_peri>;
      clock-output-names = "aclk_peri";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      #clock-init-cells = <1>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };



     hclk_peri: hclk_peri_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 2>;
      clocks = <&aclk_peri>;
      clock-output-names = "hclk_peri";
      rockchip,div-type = <(1 << (1))>;
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };



     pclk_peri: pclk_peri_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <12 2>;
      clocks = <&aclk_peri>;
      clock-output-names = "pclk_peri";
      rockchip,div-type = <(1 << (1))>;
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };



     aclk_peri: aclk_peri_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <15 1>;
      clocks = <&clk_cpll>, <&clk_gpll>;
      clock-output-names = "aclk_peri";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };
    };

    clk_sel_con11: sel-con@0070 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0070 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_sdmmc: clk_sdmmc_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 6>;
      clocks = <&hclk_peri>;
      clock-output-names = "clk_sdmmc";
      rockchip,div-type = <(0)>;
      rockchip,clkops-idx =
       <2>;
      #clock-cells = <0>;
     };



     clk_hsicphy12m: hsic_phy_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 6>;
      clocks = <&clk_hsicphy480m>;
      clock-output-names = "clk_hsicphy12m";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };



    };

    clk_sel_con12: sel-con@0074 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0074 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_sdio: clk_sdio_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 6>;
      clocks = <&hclk_peri>;
      clock-output-names = "clk_sdio";
      rockchip,div-type = <(0)>;
      rockchip,clkops-idx =
       <2>;
      #clock-cells = <0>;
     };



     clk_emmc: clk_emmc_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 6>;
      clocks = <&hclk_peri>;
      clock-output-names = "clk_emmc";
      rockchip,div-type = <(0)>;
      rockchip,clkops-idx =
       <2>;
      #clock-cells = <0>;
     };



     clk_uart_pll_mux: clk_uart_pll_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <15 1>;
      clocks = <&clk_gpll>, <&clk_cpll>;
      clock-output-names = "clk_uart_pll";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };
    };

    clk_sel_con13: sel-con@0078 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0078 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_uart0_div: clk_uart0_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&clk_uart_pll_mux>;
      clock-output-names = "clk_uart0_div";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };



     clk_uart0: clk_uart0_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 2>;
      clocks = <&clk_uart0_div>, <&clk_uart0_frac>,
             <&xin24m>;
      rockchip,clkops-idx =
       <8>;
      rockchip,flags = <(1 << (2))>;
      clock-output-names = "clk_uart0";
      #clock-cells = <0>;
     };



    };

    clk_sel_con14: sel-con@007c {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x007c 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_uart1_div: clk_uart1_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&clk_uart_pll_mux>;
      clock-output-names = "clk_uart1_div";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };



     clk_uart1: clk_uart1_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 2>;
      clocks = <&clk_uart1_div>, <&clk_uart1_frac>,
             <&xin24m>;
      rockchip,clkops-idx =
       <8>;
      rockchip,flags = <(1 << (2))>;
      clock-output-names = "clk_uart1";
      #clock-cells = <0>;
     };



    };

    clk_sel_con15: sel-con@0080 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0080 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_uart2_div: clk_uart2_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&clk_uart_pll_mux>;
      clock-output-names = "clk_uart2_div";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };



     clk_uart2: clk_uart2_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 2>;
      clocks = <&clk_uart2_div>, <&clk_uart2_frac>,
             <&xin24m>;
      rockchip,clkops-idx =
       <8>;
      rockchip,flags = <(1 << (2))>;
      clock-output-names = "clk_uart2";
      #clock-cells = <0>;
     };



    };

    clk_sel_con16: sel-con@0084 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0084 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_uart3_div: clk_uart3_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&clk_uart_pll_mux>;
      clock-output-names = "clk_uart3_div";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };



     clk_uart3: clk_uart3_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 2>;
      clocks = <&clk_uart3_div>, <&clk_uart3_frac>,
             <&xin24m>;
      rockchip,clkops-idx =
       <8>;
      rockchip,flags = <(1 << (2))>;
      clock-output-names = "clk_uart3";
      #clock-cells = <0>;
     };



    };

    clk_sel_con17: sel-con@0088 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0088 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;
     clk_uart0_frac: clk_uart0_frac {
      compatible = "rockchip,rk3188-frac-con";
      clocks = <&clk_uart0_div>;
      clock-output-names = "clk_uart0_frac";

      rockchip,bits = <0 32>;
      rockchip,clkops-idx =
       <5>;
      #clock-cells = <0>;
     };
    };
    clk_sel_con18: sel-con@008c {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x008c 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;
     clk_uart1_frac: clk_uart1_frac {
      compatible = "rockchip,rk3188-frac-con";
      clocks = <&clk_uart1_div>;
      clock-output-names = "clk_uart1_frac";

      rockchip,bits = <0 32>;
      rockchip,clkops-idx =
       <5>;
      #clock-cells = <0>;
     };
    };
    clk_sel_con19: sel-con@0090 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0090 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;
     clk_uart2_frac: clk_uart2_frac {
      compatible = "rockchip,rk3188-frac-con";
      clocks = <&clk_uart2_div>;
      clock-output-names = "clk_uart2_frac";

      rockchip,bits = <0 32>;
      rockchip,clkops-idx =
       <5>;
      #clock-cells = <0>;
     };
    };
    clk_sel_con20: sel-con@0094 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0094 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;
     clk_uart3_frac: clk_uart3_frac {
      compatible = "rockchip,rk3188-frac-con";
      clocks = <&clk_uart3_div>;
      clock-output-names = "clk_uart3_frac";

      rockchip,bits = <0 32>;
      rockchip,clkops-idx =
       <5>;
      #clock-cells = <0>;
     };
    };

    clk_sel_con21: sel-con@0098 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0098 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_mac_pll_mux: clk_mac_pll_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <0 1>;
      clocks = <&clk_gpll>, <&clk_dpll>;
      clock-output-names = "clk_mac_pll";
      #clock-cells = <0>;
     };



     clk_mac: clk_mac_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <4 1>;
      clocks = <&clk_mac_pll_mux>, <&rmii_clkin>;
      rockchip,clkops-idx =
       <10>;
      rockchip,flags = <(1 << (2))>;
      clock-output-names = "clk_mac";
      #clock-cells = <0>;
     };



     clk_mac_pll_div: clk_mac_pll_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 5>;
      clocks = <&clk_mac_pll_mux>;
      clock-output-names = "clk_mac_pll";
      rockchip,clkops-idx =
       <1>;
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };


    };

    clk_sel_con22: sel-con@009c {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x009c 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_hsadc_pll_mux: clk_hsadc_pll_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <0 1>;
      clocks = <&clk_gpll>, <&clk_cpll>;
      clock-output-names = "clk_hsadc_pll";
      #clock-cells = <0>;
     };



     clk_hsadc: clk_hsadc_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <4 2>;
      clocks = <&clk_hsadc_pll_mux>, <&clk_hsadc_frac>,
        <&clk_hsadc_ext>;
      rockchip,clkops-idx =
       <9>;
      rockchip,flags = <(1 << (2))>;
      clock-output-names = "clk_hsadc";
      #clock-cells = <0>;
     };



     clk_hsadc_inv: clk_hsadc_inv {
      compatible = "rockchip,rk3188-inv-con";
      rockchip,bits = <7 1>;
      clocks = <&clk_hsadc>;
     };

     clk_hsadc_div: clk_hsadc_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 8>;
      clocks = <&clk_hsadc_pll_mux>;
      clock-output-names = "clk_hsadc_pll";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };
    };

    clk_sel_con23: sel-con@00a0 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00a0 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_hsadc_frac: clk_hsadc_frac{
      compatible = "rockchip,rk3188-frac-con";
      clocks = <&clk_hsadc_pll_mux>;
      clock-output-names = "clk_hsadc_frac";

      rockchip,bits = <0 32>;
      rockchip,clkops-idx =
       <5>;
      #clock-cells = <0>;
     };
    };

    clk_sel_con24: sel-con@00a4 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00a4 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;
     clk_saradc: clk_saradc_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 8>;
      clocks = <&xin24m>;
      clock-output-names = "clk_saradc";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };
    };

    clk_sel_con25: sel-con@00a8 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00a8 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_spi0: clk_spi0_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&pclk_peri>;
      clock-output-names = "clk_spi0";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };

     clk_spi1: clk_spi1_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 7>;
      clocks = <&pclk_peri>;
      clock-output-names = "clk_spi1";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };

    };

    clk_sel_con26: sel-con@00ac {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00ac 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_ddr_div: clk_ddr_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 2>;
      clocks = <&clk_ddr>;
      clock-output-names = "clk_ddr";
      rockchip,div-type = <(1 << (1))>;
      rockchip,clkops-idx = <13>;
      #clock-cells = <0>;
     };



     clk_ddr: clk_ddr_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 1>;
      clocks = <&clk_dpll>,
             <&clk_gates1 7>;
      clock-output-names = "clk_ddr";
      rockchip,flags = <((1 << (6)) |
         (1 << (7)))>;
      #clock-cells = <0>;
     };


    };

    clk_sel_con27: sel-con@00b0 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00b0 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     dclk_lcdc0: dclk_lcdc0_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <0 1>;
      clocks = <&clk_cpll>, <&clk_gpll>;
      clock-output-names = "dclk_lcdc0";
      #clock-cells = <0>;
     };



     dclk_lcdc0_div: dclk_lcdc0_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 8>;
      clocks = <&dclk_lcdc0>;
      clock-output-names = "dclk_lcdc0";
      rockchip,div-type = <(0)>;
      rockchip,clkops-idx =
       <3>;
      #clock-cells = <0>;
     };
    };


    clk_sel_con28: sel-con@00b4 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00b4 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     dclk_lcdc1: dclk_lcdc1_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <0 1>;
      clocks = <&clk_cpll>, <&clk_gpll>;
      clock-output-names = "dclk_lcdc1";
      #clock-cells = <0>;
     };



     dclk_lcdc1_div: dclk_lcdc1_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 8>;
      clocks = <&dclk_lcdc1>;
      clock-output-names = "dclk_lcdc1";
      rockchip,div-type = <(0)>;
      rockchip,clkops-idx =
       <3>;
      #clock-cells = <0>;
     };
    };

    clk_sel_con29: sel-con@00b8 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00b8 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     cif_out_pll_mux: cif_out_pll_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <0 1>;
      clocks = <&clk_cpll>, <&clk_gpll>;
      clock-output-names = "cif_out_pll";
      #clock-cells = <0>;
     };

     cif0_out_div: cif0_out_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <1 5>;
      clocks = <&cif_out_pll_mux>;
      clock-output-names = "cif_out_pll";
      rockchip,div-type = <(0)>;
      rockchip,clkops-idx =
       <1>;
      #clock-cells = <0>;
     };



     clk_cif0: cif0_out_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <7 1>;
      clocks = <&cif_out_pll_mux>, <&xin24m>;
      rockchip,clkops-idx =
       <7>;
      rockchip,flags = <(1 << (2))>;
      clock-output-names = "clk_cif0";
      #clock-cells = <0>;
     };


    };

    clk_sel_con30: sel-con@00bc {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00bc 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_hsicphy480m: clk_hsicphy480m_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <0 2>;
      clocks = <&otgphy0_480m>, <&otgphy1_480m>,
        <&clk_gpll>, <&clk_cpll>;
      clock-output-names = "clk_hsicphy480m";
      #clock-cells = <0>;
     };






    };

    clk_sel_con31: sel-con@00c0 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00c0 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     aclk_lcdc0_pre_div: aclk_lcdc0_pre_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 5>;
      clocks = <&aclk_lcdc0>;
      clock-output-names = "aclk_lcdc0";
      rockchip,div-type = <(0)>;
      rockchip,clkops-idx =
       <1>;
      #clock-cells = <0>;
     };



     aclk_lcdc0: aclk_lcdc0_pre_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <7 1>;
      clocks = <&clk_cpll>, <&clk_gpll>;
      clock-output-names = "aclk_lcdc0";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     aclk_lcdc1_pre_div: aclk_lcdc1_pre_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 5>;
      clocks = <&aclk_lcdc1>;
      clock-output-names = "aclk_lcdc1";
      rockchip,div-type = <(0)>;
      rockchip,clkops-idx =
       <1>;
      #clock-cells = <0>;
     };



     aclk_lcdc1: aclk_lcdc1_pre_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <15 1>;
      clocks = <&clk_cpll>, <&clk_gpll>;
      clock-output-names = "aclk_lcdc1";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };
    };

    clk_sel_con32: sel-con@00c4 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00c4 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     aclk_vepu_div: aclk_vepu_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 5>;
      clocks = <&clk_vepu>;
      clock-output-names = "clk_vepu";
      rockchip,div-type = <(0)>;
      rockchip,clkops-idx =
       <1>;
      #clock-cells = <0>;
     };



     clk_vepu: aclk_vepu_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <7 1>;
      clocks = <&clk_cpll>, <&clk_gpll>;
      clock-output-names = "clk_vepu";
      #clock-cells = <0>;
     };

     aclk_vdpu_div: aclk_vdpu_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 5>;
      clocks = <&clk_vdpu>;
      clock-output-names = "clk_vdpu";
      rockchip,div-type = <(0)>;
      rockchip,clkops-idx =
       <1>;
      #clock-cells = <0>;
     };



     clk_vdpu: aclk_vdpu_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <15 1>;
      clocks = <&clk_cpll>, <&clk_gpll>;
      clock-output-names = "clk_vdpu";
      #clock-cells = <0>;
     };
    };

    clk_sel_con34: sel-con@00cc {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00cc 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     aclk_gpu_div: aclk_gpu_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 5>;
      clocks = <&clk_gpu>;
      clock-output-names = "clk_gpu";
      rockchip,div-type = <(0)>;
      rockchip,clkops-idx =
       <1>;
      #clock-cells = <0>;
     };



     clk_gpu: aclk_gpu_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <7 1>;
      clocks = <&clk_cpll>, <&clk_gpll>;
      clock-output-names = "clk_gpu";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };


    };
   };


   clk_gate_cons {
    compatible = "rockchip,rk-gate-cons";
    #address-cells = <1>;
    #size-cells = <1>;
    ranges ;

    clk_gates0: gate-clk@00d0 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00d0 0x4>;
     clocks = <&clk_core_peri>, <&clk_gpll>,
       <&clk_dpll>, <&aclk_cpu>,

       <&hclk_cpu>, <&pclk_cpu>,
       <&pclk_cpu>, <&aclk_core>,

       <&dummy>, <&clk_i2s_div>,
       <&clk_i2s_frac>, <&dummy>,

       <&dummy>, <&clk_spdif_div>,
       <&clk_spdif_frac>, <&dummy>;

     clock-output-names =
      "clk_core_peri", "clk_arm_gpll",
      "clk_dpll", "aclk_cpu",

      "hclk_cpu", "pclk_cpu",
      "g_atclk_cpu", "aclk_core",

      "reserved", "clk_i2s_div",
      "clk_i2s_frac", "reserved",

      "reserved", "clk_spdif_div",
      "clk_spdif_frac", "g_testclk";
      rockchip,suspend-clkgating-setting=<0x00bf 0x00bf>;

     #clock-cells = <1>;
    };

    clk_gates1: gate-clk@00d4 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00d4 0x4>;
     clocks = <&xin24m>, <&xin24m>,
       <&xin24m>, <&dummy>,

       <&aclk_lcdc1>, <&xin24m>,
       <&xin24m>, <&clk_gpll>,

       <&clk_uart0_div>, <&clk_uart0_frac>,
       <&clk_uart1_div>, <&clk_uart1_frac>,

       <&clk_uart2_div>, <&clk_uart2_frac>,
       <&clk_uart3_div>, <&clk_uart3_frac>;

     clock-output-names =
      "timer0", "timer1",
      "timer3", "g_jtag",

      "aclk_lcdc1", "g_otgphy0",
      "g_otgphy1", "clk_ddr_gpll",

      "clk_uart0_div", "clk_uart0_frac",
      "clk_uart1_div", "clk_uart1_frac",

      "clk_uart2_div", "clk_uart2_frac",
      "clk_uart3_div", "clk_uart3_frac";
      rockchip,suspend-clkgating-setting=<0x0 0x0>;

     #clock-cells = <1>;
    };

    clk_gates2: gate-clk@00d8 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00d8 0x4>;
     clocks = <&aclk_peri>, <&aclk_peri>,
       <&hclk_peri>, <&pclk_peri>,

       <&hclk_peri>, <&clk_mac_pll_mux>,
       <&clk_hsadc_pll_mux>, <&clk_hsadc_frac>,

       <&clk_saradc>, <&clk_spi0>,
       <&clk_spi1>, <&clk_sdmmc>,

       <&dummy>, <&clk_sdio>,
       <&clk_emmc>, <&dummy>;

     clock-output-names =
      "aclk_peri", "g_aclk_peri",
      "hclk_peri", "pclk_peri",

      "g_smc_src", "clk_mac_pll",
      "clk_hsadc_pll", "clk_hsadc_frac",

      "clk_saradc", "clk_spi0",
      "clk_spi1", "clk_sdmmc",

      "g_mac_lbtest", "clk_sdio",
      "clk_emmc", "reserved";

      rockchip,suspend-clkgating-setting=<0x1f 0x1b>;

     #clock-cells = <1>;
    };

    clk_gates3: gate-clk@00dc {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00dc 0x4>;
     clocks = <&aclk_lcdc0>, <&dclk_lcdc0>,
       <&dclk_lcdc1>, <&clk_cif_in>,

       <&xin24m>, <&xin24m>,
       <&clk_hsicphy480m>, <&clk_cif0>,

       <&xin24m>, <&clk_vepu>,
       <&clk_vepu>, <&clk_vdpu>,

       <&clk_vdpu>, <&dummy>,
       <&xin24m>, <&clk_gpu>;

     clock-output-names =
      "aclk_lcdc0", "dclk_lcdc0",
      "dclk_lcdc1", "g_clk_cif_in",





      "timer2", "timer4",
      "clk_hsicphy480m", "clk_cif0",

      "timer5", "clk_vepu",
      "g_h_vepu", "clk_vdpu",

      "g_h_vdpu", "reserved",
      "timer6", "clk_gpu";
     rockchip,suspend-clkgating-setting=<0x0 0x0>;

     #clock-cells = <1>;
    };

    clk_gates4: gate-clk@00e0 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00e0 0x4>;
     clocks = <&hclk_peri>, <&pclk_peri>,
       <&aclk_peri>, <&aclk_peri>,

       <&aclk_peri>, <&hclk_peri>,
       <&hclk_peri>, <&hclk_peri>,

       <&hclk_cpu>, <&hclk_cpu>,
       <&aclk_cpu>, <&dummy>,

       <&aclk_cpu>, <&dummy>,
       <&hclk_cpu>, <&hclk_cpu>;






     clock-output-names =
      "g_hp_axi_matrix", "g_pp_axi_matrix",
      "g_a_cpu_peri", "g_ap_axi_matrix",

      "g_a_peri_niu", "g_h_usb_peri",
      "g_hp_ahb_arbi", "g_h_emem_peri",

      "g_h_cpubus", "g_h_ahb2apb",
      "g_a_strc_sys", "reserved",

      "g_a_intmem", "reserved",
      "g_h_imem1", "g_h_imem0";


     rockchip,suspend-clkgating-setting=<0xd75e 0xd75e>;
     #clock-cells = <1>;
    };

    clk_gates5: gate-clk@00e4 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00e4 0x4>;
     clocks = <&aclk_cpu>, <&aclk_peri>,
       <&pclk_cpu>, <&pclk_cpu>,

       <&pclk_cpu>, <&pclk_cpu>,
       <&hclk_cpu>, <&pclk_cpu>,

       <&aclk_peri>, <&hclk_peri>,
       <&hclk_peri>, <&hclk_peri>,

       <&hclk_peri>, <&hclk_peri>;

     clock-output-names =
      "g_a_dmac1", "g_a_dmac2",
      "g_p_efuse", "g_p_tzpc",

      "g_p_grf", "g_p_pmu",
      "g_h_rom", "g_p_ddrupctl",

      "g_a_smc", "g_h_nandc",
      "g_h_sdmmc0", "g_h_sdio",

      "g_h_emmc", "g_h_otg0";
     rockchip,suspend-clkgating-setting=<0x80 0x80>;

     #clock-cells = <1>;
    };

    clk_gates6: gate-clk@00e8 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00e8 0x4>;
     clocks = <&clk_gates6 13>, <&hclk_cpu>,
       <&hclk_cpu>, <&clk_gates9 5>,

       <&hclk_cpu>, <&clk_gates6 13>,
       <&dummy>, <&dummy>,

       <&clk_gates6 13>, <&hclk_cpu>,
       <&hclk_cpu>, <&clk_gates9 5>,

       <&hclk_cpu>, <&aclk_lcdc0>;

     clock-output-names =
      "g_a_lcdc0", "g_h_lcdc0",
      "g_h_lcdc1", "g_a_lcdc1",

      "g_h_cif0", "g_a_cif0",
      "reserved", "reserved",

      "g_a_ipp", "g_h_ipp",
      "g_h_rga", "g_a_rga",

      "g_h_vio_bus", "g_a_vio0";

     rockchip,suspend-clkgating-setting=<0x0 0x0>;
     #clock-cells = <1>;
    };

    clk_gates7: gate-clk@00ec {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00ec 0x4>;
     clocks = <&hclk_peri>, <&hclk_cpu>,
       <&hclk_cpu>, <&hclk_peri>,

       <&hclk_peri>, <&hclk_peri>,
       <&hclk_peri>, <&pclk_cpu>,

       <&dummy>, <&pclk_cpu>,
       <&pclk_cpu>, <&pclk_peri>,

       <&pclk_peri>, <&pclk_peri>,
       <&pclk_peri>, <&pclk_peri>;

     clock-output-names =
      "g_h_emac", "g_h_spdif",
      "g_h_i2s0_2ch", "g_h_otg1",

      "g_h_hsic", "g_h_hsadc",
      "g_h_pidf", "g_p_timer0",

      "reserved", "g_p_timer2",
      "g_p_pwm01", "g_p_pwm23",

      "g_p_spi0", "g_p_spi1",
      "g_p_saradc", "g_p_wdt";
     rockchip,suspend-clkgating-setting=<0x0 0x0>;

     #clock-cells = <1>;
    };

    clk_gates8: gate-clk@00f0 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00f0 0x4>;
     clocks = <&pclk_ahb2apb>, <&pclk_ahb2apb>,
       <&pclk_peri>, <&pclk_peri>,

       <&pclk_cpu>, <&pclk_cpu>,
       <&pclk_peri>, <&pclk_peri>,

       <&pclk_peri>, <&pclk_cpu>,
       <&pclk_cpu>, <&pclk_cpu>,

       <&pclk_peri>, <&aclk_peri>;

     clock-output-names =
      "g_p_uart0", "g_p_uart1",
      "g_p_uart2", "g_p_uart3",

      "g_p_i2c0", "g_p_i2c1",
      "g_p_i2c2", "g_p_i2c3",

      "g_p_i2c4", "g_p_gpio0",
      "g_p_gpio1", "g_p_gpio2",

      "g_p_gpio3", "g_a_gps";
      rockchip,suspend-clkgating-setting=<0x200 0x200>;

     #clock-cells = <1>;
    };

    clk_gates9: gate-clk@00f4 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00f4 0x4>;
     clocks = <&clk_core>, <&pclk_cpu>,
       <&clk_gates0 6>, <&clk_gates0 6>,

       <&clk_core>, <&aclk_lcdc1>,
       <&pclk_cpu>, <&clk_gpu>;

     clock-output-names =
      "g_clk_core_dbg", "g_p_dbg",
      "g_clk_trace", "g_atclk",

      "g_clk_l2c", "g_a_vio1",
      "g_p_ddrpubl", "g_a_gpu";
     rockchip,suspend-clkgating-setting=<0x50 0x50>;

     #clock-cells = <1>;
    };
   };
  };
 };
};
# 9 "arch/arm/boot/dts/rk3188.dtsi" 2

/ {
 compatible = "rockchip,rk3188";
 interrupt-parent = <&gic>;
 rockchip,sram = <&sram>;

 aliases {
  serial0 = &uart0;
  serial1 = &uart1;
  serial2 = &uart2;
  serial3 = &uart3;
  i2c0 = &i2c0;
  i2c1 = &i2c1;
  i2c2 = &i2c2;
  i2c3 = &i2c3;
  i2c4 = &i2c4;
  lcdc0 = &lcdc0;
  lcdc1 = &lcdc1;
  spi0 = &spi0;
  spi1 = &spi1;
 };

 cpus {
  #address-cells = <1>;
  #size-cells = <0>;

  cpu@0 {
   device_type = "cpu";
   compatible = "arm,cortex-a9";
   reg = <0>;
  };
  cpu@1 {
   device_type = "cpu";
   compatible = "arm,cortex-a9";
   reg = <1>;
  };
  cpu@2 {
   device_type = "cpu";
   compatible = "arm,cortex-a9";
   reg = <2>;
  };
  cpu@3 {
   device_type = "cpu";
   compatible = "arm,cortex-a9";
   reg = <3>;
  };
 };

 twd-wdt@1013c620 {
  compatible = "arm,cortex-a9-twd-wdt";
  reg = <0x1013c620 0x20>;
  interrupts = <1 14 ((((1 << (4)) - 1) << 8) | 4)>;
 };

 gic: interrupt-controller@1013d000 {
  compatible = "arm,cortex-a9-gic";
  interrupt-controller;
  #interrupt-cells = <3>;
  reg = <0x1013d000 0x1000>,
        <0x1013c100 0x0100>;
 };

 L2: cache-controller@10138000 {
  compatible = "rockchip,pl310-cache", "arm,pl310-cache";
  reg = <0x10138000 0x1000>;
  cache-unified;
  cache-level = <2>;
  arm,tag-latency = <1 1 1>;
  arm,data-latency = <3 1 2>;
  rockchip,prefetch-ctrl = <0x70000003>;

  rockchip,power-ctrl = <0x3>;







  rockchip,aux-ctrl = <0x72000001 (~0x72000001)>;
 };

 cpu_axi_bus: cpu_axi_bus {
  compatible = "rockchip,cpu_axi_bus";
  #address-cells = <1>;
  #size-cells = <1>;
  ranges;
  qos {
   #address-cells = <1>;
   #size-cells = <1>;
   ranges;
   dmac {
    reg = <0x10129000 0x20>;
    rockchip,priority = <0 0>;
   };
   cpu0 {
    reg = <0x1012a000 0x20>;
    rockchip,priority = <0 0>;
   };
   cpu1_r {
    reg = <0x1012a080 0x20>;
    rockchip,priority = <0 0>;
   };
   cpu1_w {
    reg = <0x1012a100 0x20>;
    rockchip,priority = <0 0>;
   };
   peri {
    reg = <0x1012c000 0x20>;
    rockchip,priority = <2 2>;
   };
   gpu {
    reg = <0x1012d000 0x20>;
    rockchip,priority = <2 1>;
   };
   vpu {
    reg = <0x1012e000 0x20>;
   };
   vop0 {
    reg = <0x1012f000 0x20>;
    rockchip,priority = <3 3>;
   };
   cif0 {
    reg = <0x1012f080 0x20>;
   };
   ipp {
    reg = <0x1012f100 0x20>;
   };
   vop1 {
    reg = <0x1012f180 0x20>;
    rockchip,priority = <3 3>;
   };
   cif1 {
    reg = <0x1012f200 0x20>;
   };
   rga {
    reg = <0x1012f280 0x20>;
   };
  };
  msch {
   #address-cells = <1>;
   #size-cells = <1>;
   ranges;
   msch {
    reg = <0x10128000 0x18>;
    rockchip,read-latency = <0x3f>;
   };
  };
 };

 bootrom@10120000 {
  compatible = "rockchip,bootrom";
  reg = <0x10120000 0x4000>;
 };

 bootram@10080000 {
  compatible = "rockchip,bootram";
  reg = <0x10080000 0x20>;
 };

 sram: sram@10080020 {
  compatible = "mmio-sram";
  reg = <0x10080020 (0x8000 - 0x20)>;
  map-exec;
 };

 pmu@20004000 {
  compatible = "rockchip,pmu";
  reg = <0x20004000 0x4000>;
 };

 timer@20038000 {
  compatible = "rockchip,timer";
  reg = <0x20038000 0x20>;
  interrupts = <0 44 4>;
  rockchip,percpu = <0>;
 };

 timer@20038020 {
  compatible = "rockchip,timer";
  reg = <0x20038020 0x20>;
  interrupts = <0 45 4>;
  rockchip,percpu = <1>;
 };

 timer@20038040 {
  compatible = "rockchip,timer";
  reg = <0x20038040 0x20>;
  interrupts = <0 58 4>;
  rockchip,percpu = <2>;
 };

 timer@20038060 {
  compatible = "rockchip,timer";
  reg = <0x20038060 0x20>;
  interrupts = <0 59 4>;
  rockchip,percpu = <3>;
 };

 timer@20038080 {
  compatible = "rockchip,timer";
  reg = <0x20038080 0x20>;
  interrupts = <0 60 4>;
  rockchip,broadcast = <1>;
 };

 timer@200380a0 {
  compatible = "rockchip,timer";
  reg = <0x200380a0 0x20>;
  interrupts = <0 64 4>;
  rockchip,clocksource = <1>;
 };

 watchdog:wdt@2004c000 {
  compatible = "rockchip,watch dog";
  reg = <0x2004c000 0x100>;
  clocks = <&clk_gates7 15>;
  clock-names = "pclk_wdt";
  interrupts = <0 51 4>;
  rockchip,irq = <1>;
  rockchip,timeout = <5>;
  rockchip,atboot = <1>;
  rockchip,debug = <0>;
  status = "disabled";
 };

 amba {
  #address-cells = <1>;
  #size-cells = <1>;
  compatible = "arm,amba-bus";
  interrupt-parent = <&gic>;
  ranges;

  pdma0: pdma@20018000 {
   compatible = "arm,pl330", "arm,primecell";
   reg = <0x20018000 0x4000>;
   interrupts = <0 0 4>,
         <0 1 4>;
   #dma-cells = <1>;

  };

  pdma1: pdma@20078000 {
   compatible = "arm,pl330", "arm,primecell";
   reg = <0x20078000 0x4000>;
   interrupts = <0 2 4>,
         <0 3 4>;
   #dma-cells = <1>;

  };
 };

 emmc: rksdmmc@1021C000 {
  compatible = "rockchip,rk_mmc";
  reg = <0x1021C000 0x4000>;
  interrupts = <0 25 4>;
  #address-cells = <1>;
  #size-cells = <0>;


  clocks = <&clk_gates2 14>;
  num-slots = <1>;

     fifo-depth = <0x80>;
  bus-width = <4>;
 };

 sdmmc: rksdmmc@10214000 {
  compatible = "rockchip,rk_mmc";
      reg = <0x10214000 0x4000>;
      interrupts = <0 23 4>;
      #address-cells = <1>;
      #size-cells = <0>;
      pinctrl-names = "default","suspend";
      pinctrl-0 = <&sd0_clk &sd0_cmd &sd0_cd &sd0_wp &sd0_pwr &sd0_bus1 &sd0_bus4>;
      pinctrl-1 = <&sd0_cd_gpio>;
      clocks = <&clk_gates2 11>;
         num-slots = <1>;

      fifo-depth = <0x100>;
      bus-width = <4>;
 };

 sdio: rksdmmc@10218000 {
      compatible = "rockchip,rk_mmc";
      reg = <0x10218000 0x4000>;
      interrupts = <0 24 4>;
      #address-cells = <1>;
      #size-cells = <0>;
      pinctrl-names = "default","suspend";
      pinctrl-0 = <&sd1_clk &sd1_cmd &sd1_cd &sd1_wp &sd1_bus1 &sd1_bus4>;
             clocks = <&clk_gates2 13>;
             num-slots = <1>;

      fifo-depth = <0x100>;
      bus-width = <4>;
 };

 uart0: serial@10124000 {
  compatible = "rockchip,serial";
  reg = <0x10124000 0x100>;
  interrupts = <0 34 4>;
  clock-frequency = <24000000>;
  clocks = <&clk_uart0>, <&clk_gates8 0>;
  clock-names = "sclk_uart", "pclk_uart";
  reg-shift = <2>;
  reg-io-width = <4>;
  dmas = <&pdma0 0>, <&pdma0 1>;
  #dma-cells = <2>;
  pinctrl-names = "default";
  pinctrl-0 = <&uart0_xfer &uart0_cts &uart0_rts>;
  status = "disabled";
 };

 uart1: serial@10126000 {
  compatible = "rockchip,serial";
  reg = <0x10126000 0x100>;
  interrupts = <0 35 4>;
  clock-frequency = <24000000>;
  clocks = <&clk_uart1>, <&clk_gates8 1>;
  clock-names = "sclk_uart", "pclk_uart";
  reg-shift = <2>;
  reg-io-width = <4>;
  dmas = <&pdma0 2>, <&pdma0 3>;
  #dma-cells = <2>;
  pinctrl-names = "default";
  pinctrl-0 = <&uart1_xfer &uart1_cts &uart1_rts>;
  status = "disabled";
 };

 uart2: serial@20064000 {
  compatible = "rockchip,serial";
  reg = <0x20064000 0x100>;
  interrupts = <0 36 4>;
  clock-frequency = <24000000>;
  clocks = <&clk_uart2>, <&clk_gates8 2>;
  clock-names = "sclk_uart", "pclk_uart";
  current-speed = <115200>;
  reg-shift = <2>;
  reg-io-width = <4>;
  pinctrl-names = "default";
  pinctrl-0 = <&uart2_xfer>;
  status = "disabled";
 };

 uart3: serial@20068000 {
  compatible = "rockchip,serial";
  reg = <0x20068000 0x100>;
  interrupts = <0 37 4>;
  clock-frequency = <24000000>;
  clocks = <&clk_uart3>, <&clk_gates8 3>;
  clock-names = "sclk_uart", "pclk_uart";
  reg-shift = <2>;
  reg-io-width = <4>;
  dmas = <&pdma1 8>, <&pdma1 9>;
  #dma-cells = <2>;
  pinctrl-names = "default";
  pinctrl-0 = <&uart3_xfer &uart3_cts &uart3_rts>;
  status = "disabled";
 };

 fiq-debugger {
  compatible = "rockchip,fiq-debugger";
  rockchip,serial-id = <2>;
  rockchip,signal-irq = <112>;
  rockchip,wake-irq = <0>;
  status = "disabled";
 };

 spi0: spi@20070000 {
  compatible = "rockchip,rockchip-spi";
  reg = <0x20070000 0x1000>;
  interrupts = <0 38 4>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&spi0_txd &spi0_rxd &spi0_clk &spi0_cs0 &spi0_cs1>;
  rockchip,spi-src-clk = <0>;
         num-cs = <2>;
  clocks =<&clk_spi0>, <&clk_gates7 12>;
  clock-names = "spi","pclk_spi0";
  dmas = <&pdma1 10>, <&pdma1 11>;
  #dma-cells = <2>;
  dma-names = "tx", "rx";
  status = "disabled";
 };

 spi1: spi@20074000 {
  compatible = "rockchip,rockchip-spi";
  reg = <0x20074000 0x1000>;
  interrupts = <0 39 4>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&spi1_txd &spi1_rxd &spi1_clk &spi1_cs0 &spi1_cs1>;
  rockchip,spi-src-clk = <1>;
         num-cs = <2>;
  clocks = <&clk_spi1>, <&clk_gates7 13>;
  clock-names = "spi","pclk_spi1";
  dmas = <&pdma1 12>, <&pdma1 13>;
  #dma-cells = <2>;
  dma-names = "tx", "rx";
  status = "disabled";
 };

 i2c0: i2c@2002d000 {
  compatible = "rockchip,rk30-i2c";
  reg = <0x2002d000 0x1000>;
  interrupts = <0 40 4>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default", "gpio";
  pinctrl-0 = <&i2c0_sda &i2c0_scl>;
  pinctrl-1 = <&i2c0_gpio>;
  gpios = <&gpio1 24 1>, <&gpio1 25 1>;
  clocks = <&clk_gates8 4>;
  rockchip,check-idle = <1>;
  status = "disabled";
 };

 i2c1: i2c@2002f000 {
  compatible = "rockchip,rk30-i2c";
  reg = <0x2002f000 0x1000>;
  interrupts = <0 41 4>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default", "gpio";
  pinctrl-0 = <&i2c1_sda &i2c1_scl>;
  pinctrl-1 = <&i2c1_gpio>;
  gpios = <&gpio1 26 1>, <&gpio1 27 1>;
  clocks = <&clk_gates8 5>;
  rockchip,check-idle = <1>;
  status = "disabled";
 };

 i2c2: i2c@20056000 {
  compatible = "rockchip,rk30-i2c";
  reg = <0x20056000 0x1000>;
  interrupts = <0 42 4>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default", "gpio";
  pinctrl-0 = <&i2c2_sda &i2c2_scl>;
  pinctrl-1 = <&i2c2_gpio>;
  gpios = <&gpio1 28 1>, <&gpio1 29 1>;
  clocks = <&clk_gates8 6>;
  rockchip,check-idle = <1>;
  status = "disabled";
 };

 i2c3: i2c@2005a000 {
  compatible = "rockchip,rk30-i2c";
  reg = <0x2005a000 0x1000>;
  interrupts = <0 43 4>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default", "gpio";
  pinctrl-0 = <&i2c3_sda &i2c3_scl>;
  pinctrl-1 = <&i2c3_gpio>;
  gpios = <&gpio3 14 1>, <&gpio3 15 1>;
  clocks = <&clk_gates8 7>;
  rockchip,check-idle = <1>;
  status = "disabled";
 };

 i2c4: i2c@2005e000 {
  compatible = "rockchip,rk30-i2c";
  reg = <0x2005e000 0x1000>;
  interrupts = <0 52 4>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default", "gpio";
  pinctrl-0 = <&i2c4_sda &i2c4_scl>;
  pinctrl-1 = <&i2c4_gpio>;
  gpios = <&gpio1 30 1>, <&gpio1 31 1>;
  clocks = <&clk_gates8 8>;
  rockchip,check-idle = <1>;
  status = "disabled";
 };

 clocks-init{
  compatible = "rockchip,clocks-init";
  rockchip,clocks-init-parent =
   <&clk_core &clk_apll>, <&aclk_cpu &clk_gpll>,
   <&aclk_peri &clk_gpll>, <&clk_i2s_pll_mux &clk_cpll>,
   <&clk_uart_pll_mux &clk_gpll>;
  rockchip,clocks-init-rate =
   <&clk_core 792000000>, <&clk_gpll 768000000>,
   <&clk_cpll 594000000>, <&aclk_cpu 192000000>,
   <&hclk_cpu 96000000>, <&pclk_cpu 48000000>,
   <&pclk_ahb2apb 48000000>, <&aclk_peri 192000000>,
   <&hclk_peri 96000000>, <&pclk_peri 48000000>,
   <&clk_gpu 200000000>, <&aclk_lcdc0 300000000>,
   <&aclk_lcdc1 300000000>;
 };
 rockchip_suspend {


                rockchip,ctrbits = <
                    (
                    (1 << (0))
                    |(1 << (1))
                    |(1 << (2))
                    |(1 << (7))
                    )
                   >;
              rockchip,pmic-gpios=<
                                                (0 |(((0x0A00)&((0xffff))) << ((0))) |((((1))&((0x3))) << ((26))) |((((0))&((0x3))) << ((28))) )
                                                (0 |(((0x0A10)&((0xffff))) << ((0))) |((((0))&((0x3))) << ((26))) |((((0x1))&((0x3))) << ((24))) )
                                                >;

        };
 fb: fb{
  compatible = "rockchip,rk-fb";
  rockchip,disp-mode = <2>;
 };

 rk_screen: rk_screen{
  compatible = "rockchip,screen";
 };

 nandc: nandc {
  compatible = "rockchip,rk-nandc";
  reg = <0x10050000 0x4000>;
  interrupts = <0 27 4>;
 };

 lcdc0:lcdc@1010c000 {
  compatible = "rockchip,rk3188-lcdc";
  rockchip,prop = <1>;
  rochchip,pwr18 = <0>;
  reg = <0x1010c000 0x1000>;
  interrupts = <0 13 4>;
  status = "disabled";
 };

 lcdc1:lcdc@1010e000 {
  compatible = "rockchip,rk3188-lcdc";
  rockchip,prop = <2>;
  rockchip,pwr18 = <0>;
  reg = <0x1010e000 0x1000>;
  interrupts = <0 14 4>;
  pinctrl-names = "default", "gpio";
  pinctrl-0 = <&lcdc1_lcdc>;
  pinctrl-1 = <&lcdc1_gpio>;
  status = "disabled";
   };

 rga@10114000 {
  compatible = "rockchip,rga";
  reg = <0x10114000 0x1000>;
  interrupts = <0 63 4>;
  clocks = <&clk_gates6 10>, <&clk_gates6 11>;
  clock-names = "hclk_rga", "aclk_rga";
 };

 adc: adc@2006c000 {
  compatible = "rockchip,saradc";
  reg = <0x2006c000 0x100>;
  interrupts = <0 26 4>;
  #io-channel-cells = <1>;
  io-channel-ranges;
  rockchip,adc-vref = <1800>;
  clock-frequency = <1000000>;
  clocks = <&clk_saradc>, <&clk_gates7 14>;
  clock-names = "saradc", "pclk_saradc";
  status = "disabled";
 };

 spdif: rockchip-spdif@0x1011e000 {
  compatible = "rockchip-spdif";
  reg = <0x1011e000 0x2000>;
  clocks = <&clk_spdif>;
  interrupts = <0 33 4>;
  dmas = <&pdma0 8>;
  dma-names = "tx";
  pinctrl-names = "default";
  pinctrl-0 = <&spdif_tx>;
 };

 i2s0: rockchip-i2s@0x1011a000 {
  compatible = "rockchip-i2s";
  reg = <0x1011a000 0x2000>;
  i2s-id = <0>;
  clocks = <&clk_i2s>;
  clock-names = "i2s_clk";
  interrupts = <0 31 4>;
  dmas = <&pdma0 6>,
   <&pdma0 7>;
  dma-names = "tx", "rx";
  pinctrl-names = "default", "sleep";
  pinctrl-0 = <&i2s0_mclk &i2s0_sclk &i2s0_lrckrx &i2s0_lrcktx &i2s0_sdi &i2s0_sdo>;
  pinctrl-1 = <&i2s0_gpio>;
 };

 pwm0: pwm@20030000{
                compatible = "rockchip,pwm";
                reg = <0x20030000 0x10>;
                #pwm-cells = <2>;
                pinctrl-names = "default";
                pinctrl-0 = <&pwm0_pin>;
  clocks = <&clk_gates7 10>;
  clock-names = "pclk_pwm";
                status = "disabled";

        };

        pwm1: pwm@20030010{
                compatible = "rockchip,pwm";
                reg = <0x20030010 0x10>;
                #pwm-cells = <2>;
                pinctrl-names = "default";
                pinctrl-0 = <&pwm1_pin>;
  clocks = <&clk_gates7 10>;
  clock-names = "pclk_pwm";
                status = "disabled";

        };
     pwm2: pwm@20050020{
                compatible = "rockchip,pwm";
                reg = <0x20050020 0x10>;
                #pwm-cells = <2>;
                pinctrl-names = "default";
  clock-names = "pclk_pwm";
  clocks = <&clk_gates7 11>;
                pinctrl-0 = <&pwm2_pin>;
                status = "disabled";

        };

        pwm3: pwm@20050030{
                compatible = "rockchip,pwm";
                reg = <0x20050030 0x10>;
                #pwm-cells = <2>;
                pinctrl-names = "default";
                pinctrl-0 = <&pwm3_pin>;
  clocks = <&clk_gates7 11>;
  clock-names = "pclk_pwm";
                status = "disabled";

        };
 dvfs {
  vd_arm:
  vd_arm {
   regulator_name="vdd_arm";
   suspend_volt=<1000>;
   pd_a9 {
    clk_core_dvfs_table:
    clk_core {
     operating-points = <

      312000 900000
      504000 950000
      816000 1000000
      1008000 1100000
      1200000 1200000
      1416000 1300000
      1608000 1350000
      >;
     status = "okay";
    };
   };
  };

  vd_logic:
  vd_logic {
   regulator_name="vdd_logic";
   suspend_volt=<1000>;

   pd_gpu {
    clk_gpu_dvfs_table:
    clk_gpu {
     operating-points = <

      200000 1200000
      300000 1200000
      400000 1200000
      >;
     status = "okay";
    };
   };

   pd_ddr {
    clk_ddr_dvfs_table:
    clk_ddr {
     operating-points = <

      200000 1200000
      300000 1200000
      400000 1200000
      >;
     status = "disable";
    };
   };
  };
 };
 ion{
  compatible = "rockchip,ion";
  #address-cells = <1>;
  #size-cells = <0>;
  rockchip,ion-heap@1 {
   compatible = "rockchip,ion-reserve";
   reg = <1>;
   memory-reservation = <0x00000000 0x10000000>;
  };
  rockchip,ion-heap@3 {
   reg = <3>;
  };
 };

 dwc_control_usb: dwc-control-usb@200080ac {
  compatible = "rockchip,rk3188-dwc-control-usb";
  reg = <0x200080ac 0x4>,
        <0x2000810c 0x10>,
        <0x2000811c 0x10>,
        <0x2000812c 0x8>,
        <0x20008138 0x8>;
  reg-names = "GRF_SOC_STATUS0",
                    "GRF_UOC0_BASE",
                    "GRF_UOC1_BASE",
                    "GRF_UOC2_BASE",
                    "GRF_UOC3_BASE";
  interrupts = <0 6 4>;
  interrupt-names = "otg_bvalid";
  gpios = <&gpio0 16 1>, <&gpio3 29 1>;
  clocks = <&clk_gates4 5>;
  clock-names = "hclk_usb_peri";
  rockchip,remote_wakeup;
  rockchip,usb_irq_wakeup;

  usb_bc{
   compatible = "rockchip,ctrl";
   rk_usb,bvalid = <0xac 10 1>;
   rk_usb,iddig = <0xac 13 1>;
   rk_usb,line = <0xac 11 2>;
   rk_usb,softctrl = <0x114 2 1>;
   rk_usb,opmode = <0x118 1 2>;
   rk_usb,xcvrsel = <0x118 3 2>;
   rk_usb,termsel = <0x118 5 1>;
  };
 };


 usb0: usb@10180000 {
  compatible = "rockchip,rk3188_usb20_otg";
  reg = <0x10180000 0x40000>;
  interrupts = <0 16 4>;
  clocks = <&clk_gates1 5>, <&clk_gates5 13>;
  clock-names = "clk_usbphy0", "hclk_usb0";

  rockchip,usb-mode = <0>;
 };

 usb1: usb@101c0000 {
  compatible = "rockchip,rk3188_usb20_host";
  reg = <0x101c0000 0x40000>;
  interrupts = <0 17 4>;
  clocks = <&clk_gates1 6>, <&clk_gates7 3>;
  clock-names = "clk_usbphy1", "hclk_usb1";
 };

 hsic: hsic@10240000 {
  compatible = "rockchip,rk3188_rk_hsic_host";
  reg = <0x10240000 0x40000>;
  interrupts = <0 5 4>;
  clocks = <&clk_hsicphy480m>, <&clk_gates7 4>,
                 <&clk_hsicphy12m>, <&otgphy1_480m>;
  clock-names = "hsicphy_480m", "hclk_hsic",
                      "hsicphy_12m", "hsic_usbphy1";
 };

 vmac@10204000 {
  compatible = "rockchip,vmac";
  reg = <0x10204000 0x4000>;
  interrupts = <0 19 4>;
  pinctrl-names = "default", "gpio";
  pinctrl-0 = <&rmii_clkoutpin &rmii_txpins &rmii_rxpins &rmii_mdpins>;
  pinctrl-1 = <&rmii_clkinpin &rmii_txpins &rmii_rxpins &rmii_mdpins>;
 };

 ap0_vcc_domain: ap0-vcc-domain {
   compatible = "rockchip,io_vol_domain";
   pinctrl-names = "default", "1.8V", "3.3V";
   pinctrl-0 = <&ap0_vcc >;
   pinctrl-1 = <&ap0_vcc_18>;
   pinctrl-2 = <&ap0_vcc_33>;
 };
 ap1_vcc_domain: ap1-vcc-domain{
   compatible = "rockchip,io_vol_domain";
   pinctrl-names = "default", "1.8V", "3.3V";
   pinctrl-0 = <&ap1_vcc >;
   pinctrl-1 = <&ap1_vcc_18>;
   pinctrl-2 = <&ap1_vcc_33>;
 };
 cif_vcc_domain: cif-vcc-domain{
   compatible = "rockchip,io_vol_domain";
   pinctrl-names = "default", "1.8V", "3.3V";
   pinctrl-0 = <&cif_vcc>;
   pinctrl-1 = <&cif_vcc_18>;
   pinctrl-2 = <&cif_vcc_33>;
 };
 flash_vcc_domain: flash-vcc-domain{
   compatible = "rockchip,io_vol_domain";
   pinctrl-names = "default", "1.8V", "3.3V";
   pinctrl-0 = <&flash_vcc>;
   pinctrl-1 = <&flash_vcc_18>;
   pinctrl-2 = <&flash_vcc_33>;
 };
 vccio0_vcc_domain: vccio0-vcc-domain{
   compatible = "rockchip,io_vol_domain";
   pinctrl-names = "default", "1.8V", "3.3V";
   pinctrl-0 = <&vccio0_vcc>;
   pinctrl-1 = <&vccio0_vcc_18>;
   pinctrl-2 = <&vccio0_vcc_33>;
 };
 vccio1_vcc_domain: vccio1-vcc-domain{
   compatible = "rockchip,io_vol_domain";
   pinctrl-names = "default", "1.8V", "3.3V";
   pinctrl-0 = <&vccio1_vcc>;
   pinctrl-1 = <&vccio1_vcc_18>;
   pinctrl-2 = <&vccio1_vcc_33>;
 };
 lcdc0_vcc_domain: lcdc0-vcc-domain{
   compatible = "rockchip,io_vol_domain";
   pinctrl-names = "default", "1.8V", "3.3V";
   pinctrl-0 = <&lcdc0_vcc>;
   pinctrl-1 = <&lcdc0_vcc_18>;
   pinctrl-2 = <&lcdc0_vcc_33>;
 };
 lcdc1_vcc_domain: lcdc1-vcc-domain{
   compatible = "rockchip,io_vol_domain";
   pinctrl-names = "default", "1.8V", "3.3V";
   pinctrl-0 = <&lcdc1_vcc>;
   pinctrl-1 = <&lcdc1_vcc_18>;
   pinctrl-2 = <&lcdc1_vcc_33>;
 };

};
# 4 "arch/arm/boot/dts/rk3188-tb.dts" 2
# 1 "arch/arm/boot/dts/lcd-b101ew05.dtsi" 1





/ {

 backlight {
  compatible = "pwm-backlight";
  pwms = <&pwm0 0 25000>;
  brightness-levels = < 220 219 218 217 216 215 214 213 212 211 210 209 208 207 206 205 204 203 202 201 200 199 198 197 196 195 194 193 192 191 190 189 188 187 186 185 184 183 182 181 180 179 178 177 176 175 174 173 172 171 170 169 168 167 166 165 164 163 162 161 160 159 158 157 156 155 154 153 152 151 150 149 148 147 146 145 144 143 142 141 140 139 138 137 136 135 134 133 132 131 130 129 128 127 126 125 124 123 122 121 120 119 118 117 116 115 114 113 112 111 110 109 108 107 106 105 104 103 102 101 100 99 98 97 96 95 94 93 92 91 90 89 88 87 86 85 84 83 82 81 80 79 78 77 76 75 74 73 72 71 70 69 68 67 66 65 64 63 62 61 60 59 58 57 56 55 54 53 52 51 50 49 48 47 46 45 44 43 42 41 40 39 38 37 36 35 34 33 32 31 30 29 28 27 26 25 24 23 22 21 20 19 18 17 16 15 14 13 12 11 10 9 8 7 6 5 4 3 2 1 0>;
  default-brightness-level = <128>;
  enable-gpios = <&gpio1 7 0>;
 };

  disp_timings: display-timings {
                        native-mode = <&timing0>;
                        timing0: timing0 {
    screen-type = <2>;
    lvds-format = <1>;
    out-face = <0x21>;
    color-mode = <0>;
    clock-frequency = <71000000>;
    hactive = <1280>;
    vactive = <800>;
    hback-porch = <100>;
    hfront-porch = <18>;
    vback-porch = <8>;
    vfront-porch = <6>;
    hsync-len = <10>;
    vsync-len = <2>;
    hsync-active = <0>;
    vsync-active = <0>;
    de-active = <0>;
    pixelclk-active = <0>;
    swap-rb = <0>;
    swap-rg = <0>;
    swap-gb = <0>;
                      };
               };
};
# 5 "arch/arm/boot/dts/rk3188-tb.dts" 2

/ {
 memory {
  device_type = "memory";
  reg = <0x60000000 0x40000000>;
 };

 chosen {
  bootargs = "clk_ignore_unused";
 };

 fiq-debugger {
  status = "okay";
 };


 wireless-wlan {
  compatible = "wlan-platdata";

  wifi_chip_type = "";
  sdio_vref = <28000>;


  pmu_regulator = "act_ldo3";
  pmu_enable_level = <1>;

  WIFI,poweren_gpio = <&gpio3 24 0>;
  WIFI,host_wake_irq = <&gpio3 26 0>;


  status = "okay";
 };

 wireless-bluetooth {
  compatible = "bluetooth-platdata";

  uart_rts_gpios = <&gpio1 3 1>;
  pinctrl-names = "default","rts_gpio";
  pinctrl-0 = <&uart0_rts>;
  pinctrl-1 = <&uart0_rts_gpio>;

  BT,power_gpio = <&gpio3 23 0>;
  BT,reset_gpio = <&gpio3 25 0>;
  BT,wake_gpio = <&gpio3 22 0>;
  BT,wake_host_irq = <&gpio0 5 1>;

  status = "okay";
 };

 backlight {
  compatible = "pwm-backlight";
  pwms = <&pwm3 0 25000>;
  brightness-levels = <0 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 70 71 72 73 74 75 76 77 78 79 80 81 82 83 84 85 86 87 88 89 90 91 92 93 94 95 96 97 98 99 100 101 102 103 104 105 106 107 108 109 110 111 112 113 114 115 116 117 118 119 120 121 122 123 124 125 126 127 128 129 130 131 132 133 134 135 136 137 138 139 140 141 142 143 144 145 146 147 148 149 150 151 152 153 154 155 156 157 158 159 160 161 162 163 164 165 166 167 168 169 170 171 172 173 174 175 176 177 178 179 180 181 182 183 184 185 186 187 188 189 190 191 192 193 194 195 196 197 198 199 200 201 202 203 204 205 206 207 208 209 210 211 212 213 214 215 216 217 218 219 220 221 222 223 224 225 226 227 228 229 230 231 232 233 234 235 236 237 238 239 240 241 242 243 244 245 246 247 248 249 250 251 252 253 254 255>;
  default-brightness-level = <128>;
  enable-gpios = <&gpio0 2 0>;
 };

 pwm_regulator {
       compatible = "rockchip_pwm_regulator";
 pwms = <&pwm0 0 25000>;
 rockchip,pwm_id= <0>;
       rockchip,pwm_voltage_map= <925000 950000 975000 1000000 1025000 1050000 1075000 1100000 1125000 1150000 1175000 1200000 1225000 1250000 1275000 1300000 1325000 1350000 1375000 1400000>;
 rockchip,pwm_voltage= <1000000>;
 rockchip,pwm_min_voltage= <925000>;
 rockchip,pwm_max_voltage= <1400000>;
 rockchip,pwm_suspend_voltage= <950000>;
 rockchip,pwm_coefficient= <475>;
 regulators {
  #address-cells = <1>;
  #size-cells = <0>;
   pwm_reg0: regulator@0{
   regulator-compatible = "pwm_dcdc1";
   regulator-name= "vdd_gpu";
   regulator-min-microvolt = <925000>;
   regulator-max-microvolt = <1400000>;
   regulator-always-on;
   regulator-boot-on;
  };
     };
 };


 codec_hdmi_i2s: codec-hdmi-i2s {
  compatible = "hdmi-i2s";
 };

 codec_hdmi_spdif: codec-hdmi-spdif {
  compatible = "hdmi-spdif";
 };

 rockchip-rt5631 {
  compatible = "rockchip-rt5631";
  dais {
   dai0 {
    audio-codec = <&rt5631>;
    audio-controller = <&i2s0>;
    format = "i2s";





   };
  };
 };

 rockchip-rk610 {
  compatible = "rockchip-rk610";
  dais {
   dai0 {
    audio-codec = <&rk610_codec>;
    audio-controller = <&i2s0>;
    format = "i2s";





   };
  };
 };

 rockchip-hdmi-i2s {
  compatible = "rockchip-hdmi-i2s";
  dais {
   dai0 {
    audio-codec = <&codec_hdmi_i2s>;
    audio-controller = <&i2s0>;
    format = "i2s";





   };
  };
 };

 rockchip-hdmi-spdif {
  compatible = "rockchip-hdmi-spdif";
  dais {
   dai0 {
    audio-codec = <&codec_hdmi_spdif>;
    audio-controller = <&spdif>;
   };
  };
 };

 vmac-phy {
  compatible = "rockchip,vmac-phy";
  power-gpios = <&gpio0 16 0>;
 };

};

&pinctrl {

 gpio1_gpio {
   gpio1_a2: gpio1-a2 {
    rockchip,pins = <0x1a20>;
    rockchip,pull = <1>;
   };


  };



};


&emmc {
 clock-frequency = <50000000>;
        clock-freq-min-max = <400000 50000000>;

        supports-highspeed;
 supports-emmc;
        bootpart-no-access;

     status = "okay";
};

&sdmmc {
 clock-frequency = <50000000>;
 lock-freq-min-max = <400000 50000000>;

 supports-highspeed;
 supports-sd;
 broken-cd;
 card-detect-delay = <200>;

 pwr-gpios = <&gpio3 1 1>;

 status = "okay";
};

&sdio {
 clock-frequency = <50000000>;
        clock-freq-min-max = <200000 50000000>;

   supports-highspeed;
 supports-sdio;
 cap-sdio-irq;
 status = "okay";
};


&uart0 {
 status = "okay";
 dma-names = "!tx", "!rx";
 pinctrl-0 = <&uart0_xfer &uart0_cts>;
};

&uart3 {
 status = "okay";
 dma-names = "!tx", "!rx";
};

&watchdog {
 rockchip,timeout = <50>;
 rockchip,debug = <1>;
 status = "disabled";
};

&spi0 {
 status = "okay";
 max-freq = <48000000>;
# 252 "arch/arm/boot/dts/rk3188-tb.dts"
};

&spi1 {
 status = "okay";
 max-freq = <48000000>;
# 276 "arch/arm/boot/dts/rk3188-tb.dts"
};


&i2c0 {
 status = "okay";
 rt5631: rt5631@1a {
  compatible = "rt5631";
  reg = <0x1a>;
 };

 rk610ctl@40 {
  compatible = "rk610_ctl";
  reg = <0x40>;
  rk610-reset-io = <&gpio3 10 0>;
  clocks = <&clk_i2s>;
  clock-names = "i2s_clk";
 };

 rk610_codec: rk610codec@60 {
  compatible = "rk610_codec";
  reg = <0x60>;
  spk_ctl_io = <&gpio2 31 0>;
  boot_depop = <1>;
  pa_enable_time = <1000>;
 };

 sensor@1d {
  compatible = "gs_mma8452";
  reg = <0x1d>;
  type = <2>;
  irq-gpio = <&gpio0 15 2>;
  irq_enable = <1>;
  poll_delay_ms = <30>;
  layout = <1>;
 };
};

&i2c1 {
 status = "okay";
 rtc@51 {
  compatible = "nxp,pcf8563";
  reg = <0x51>;
 };

 act8846: act8846@5a {
  reg = <0x5a>;
  status = "okay";
 };
 rk808: rk808@1b {
  reg = <0x1b>;
  status = "okay";
 };
 bq24296: bq24296@6b {
  compatible = "ti,bq24296";
  reg = <0x6b>;

   bq24296,chg_current = <1000 500 2000>;
  status = "disable";
 };
 bq27320: bq27320@55 {
  compatible = "ti,bq27320";
  reg = <0x55>;

  status = "disable";
 };
};

&i2c2 {
 status = "okay";
 ts@55 {
  compatible = "goodix,gt8xx";
  reg = <0x55>;
  touch-gpio = <&gpio1 15 8>;
  reset-gpio = <&gpio0 14 1>;
  power-gpio = <&gpio0 21 1>;
  max-x = <1280>;
  max-y = <800>;
 };
 ts@01 {
  compatible = "ct,ct36x";
  reg = <0x01>;
  ct-model = <365>;
  touch-gpio = <&gpio1 15 8>;
  reset-gpio = <&gpio0 14 0>;
  max-x = <1280>;
  max-y = <800>;
  orientation=<1 0 0 1>;
 };
};

&i2c3 {
 status = "okay";
};

&fb {
 rockchip,disp-mode = <2>;
};

&rk_screen {
  display-timings = <&disp_timings>;
};

&lcdc0 {
 status = "okay";
 power_ctr: power_ctr {
  rockchip,debug = <0>;
  lcd_en:lcd_en {
   rockchip,power_type = <0>;
   gpios = <&gpio0 8 0>;
   rockchip,delay = <10>;
  };
# 399 "arch/arm/boot/dts/rk3188-tb.dts"
 };
};

&lcdc1 {
 status = "okay";
};

&adc {
 status = "okay";

 key {
  compatible = "rockchip,key";
  io-channels = <&adc 1>;

  vol-up-key {
   linux,code = <115>;
   label = "volume up";
   rockchip,adc_value = <1>;
  };

  vol-down-key {
   linux,code = <114>;
   label = "volume down";
   rockchip,adc_value = <170>;
  };

  power-key {
   gpios = <&gpio0 4 1>;
   linux,code = <116>;
   label = "power";
   gpio-key,wakeup;
  };

  menu-key {
   linux,code = <139>;
   label = "menu";
   rockchip,adc_value = <355>;
  };

  home-key {
   linux,code = <102>;
   label = "home";
   rockchip,adc_value = <746>;
  };

  back-key {
   linux,code = <158>;
   label = "back";
   rockchip,adc_value = <560>;
  };

  camera-key {
   linux,code = <212>;
   label = "camera";
   rockchip,adc_value = <450>;
  };
 };
};

&pwm3 {
 status = "okay";
};

&pwm0 {
        status = "disable";
};

&clk_core_dvfs_table {
 operating-points = <

  312000 1100000
  504000 1100000
  816000 1100000
  1008000 1100000
  1200000 1200000
  1416000 1300000
  1608000 1350000
  >;
};

&clk_gpu_dvfs_table {
 operating-points = <

  200000 1200000
  300000 1200000
  400000 1200000
  >;
};

&clk_ddr_dvfs_table {
 operating-points = <

  200000 1200000
  300000 1200000
  400000 1200000
  >;

 freq_table = <

  SYS_STATUS_NORMAL 400000
  SYS_STATUS_SUSPEND 200000
  SYS_STATUS_VIDEO 300000
  SYS_STATUS_DUALVIEW 500000
  >;
};

/include/ "act8846.dtsi"
&act8846 {
 gpios =<&gpio3 27 1>;

 regulators {

  dcdc1_reg: regulator@0{
   regulator-name= "act_dcdc1";
   regulator-min-microvolt = <1200000>;
   regulator-max-microvolt = <1200000>;
   regulator-always-on;
   regulator-boot-on;
  };

  dcdc2_reg: regulator@1 {
   regulator-name= "vdd_logic";
   regulator-min-microvolt = <700000>;
   regulator-max-microvolt = <1500000>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-enabled;
    regulator-state-uv = <1200000>;
   };
  };

  dcdc3_reg: regulator@2 {
   regulator-name= "vdd_arm";
   regulator-min-microvolt = <700000>;
   regulator-max-microvolt = <1500000>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-enabled;
    regulator-state-uv = <1200000>;
   };
  };

  dcdc4_reg: regulator@3 {
   regulator-name= "vccio";
   regulator-min-microvolt = <1800000>;
   regulator-max-microvolt = <3300000>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-enabled;
    regulator-state-uv = <3300000>;
   };
  };

  ldo1_reg: regulator@4 {
   regulator-name= "act_ldo1";
   regulator-min-microvolt = <1000000>;
   regulator-max-microvolt = <1000000>;

  };

  ldo2_reg: regulator@5 {
   regulator-name= "act_ldo2";
   regulator-min-microvolt = <1200000>;
   regulator-max-microvolt = <1200000>;

  };

  ldo3_reg: regulator@6 {
   regulator-name= "act_ldo3";
   regulator-min-microvolt = <1800000>;
   regulator-max-microvolt = <1800000>;

  };

  ldo4_reg:regulator@7 {
   regulator-name= "act_ldo4";
   regulator-min-microvolt = <3300000>;
   regulator-max-microvolt = <3300000>;

  };

  ldo5_reg: regulator@8 {
   regulator-name= "act_ldo5";
   regulator-min-microvolt = <3300000>;
   regulator-max-microvolt = <3300000>;

  };

  ldo6_reg: regulator@9 {
   regulator-name= "act_ldo6";
   regulator-min-microvolt = <3300000>;
   regulator-max-microvolt = <3300000>;

  };

  ldo7_reg: regulator@10 {
   regulator-name= "act_ldo7";
   regulator-min-microvolt = <1800000>;
   regulator-max-microvolt = <1800000>;

  };

  ldo8_reg: regulator@11 {
   regulator-name= "act_ldo8";
   regulator-min-microvolt = <2800000>;
   regulator-max-microvolt = <2800000>;

  };
 };
};

/include/ "rk808.dtsi"
&rk808 {
 gpios =<&gpio0 11 0>,<&gpio0 1 1>;

 regulators {

  rk808_dcdc1_reg: regulator@0{
   regulator-name= "vdd_arm";
   regulator-always-on;
   regulator-boot-on;
  };

  rk808_dcdc2_reg: regulator@1 {
   regulator-name= "vdd_logic";
   regulator-always-on;
   regulator-boot-on;
  };

  rk808_dcdc3_reg: regulator@2 {
   regulator-name= "rk_dcdc3";
   regulator-min-microvolt = <1200000>;
   regulator-max-microvolt = <1200000>;
   regulator-always-on;
   regulator-boot-on;
  };

  rk808_dcdc4_reg: regulator@3 {
   regulator-name= "vccio";
   regulator-min-microvolt = <1800000>;
   regulator-max-microvolt = <3300000>;
   regulator-always-on;
   regulator-boot-on;
  };

  rk808_ldo1_reg: regulator@4 {
   regulator-name= "rk_ldo1";
   regulator-min-microvolt = <3300000>;
   regulator-max-microvolt = <3300000>;
   regulator-always-on;
   regulator-boot-on;
  };

  rk808_ldo2_reg: regulator@5 {
   regulator-name= "rk_ldo2";
   regulator-min-microvolt = <3300000>;
   regulator-max-microvolt = <3300000>;
   regulator-always-on;
   regulator-boot-on;
  };

  rk808_ldo3_reg: regulator@6 {
   regulator-name= "rk_ldo3";
   regulator-min-microvolt = <1000000>;
   regulator-max-microvolt = <1000000>;
   regulator-always-on;
   regulator-boot-on;
  };

  rk808_ldo4_reg:regulator@7 {
   regulator-name= "rk_ldo4";
   regulator-min-microvolt = <1800000>;
   regulator-max-microvolt = <1800000>;
   regulator-always-on;
   regulator-boot-on;
  };

  rk808_ldo5_reg: regulator@8 {
   regulator-name= "rk_ldo5";
   regulator-min-microvolt = <2800000>;
   regulator-max-microvolt = <2800000>;
   regulator-always-on;
   regulator-boot-on;
  };

  rk808_ldo6_reg: regulator@9 {
   regulator-name= "rk_ldo6";
   regulator-min-microvolt = <1200000>;
   regulator-max-microvolt = <1200000>;
   regulator-always-on;
   regulator-boot-on;
  };

  rk808_ldo7_reg: regulator@10 {
   regulator-name= "rk_ldo7";
   regulator-min-microvolt = <1800000>;
   regulator-max-microvolt = <1800000>;
   regulator-always-on;
   regulator-boot-on;
  };

  rk808_ldo8_reg: regulator@11 {
   regulator-name= "rk_ldo8";
   regulator-min-microvolt = <1800000>;
   regulator-max-microvolt = <1800000>;
   regulator-always-on;
   regulator-boot-on;
  };
 };
};

&ap0_vcc_domain{
 regulator-name= "vccio_wl";
};
&ap1_vcc_domain{
 regulator-name= "vccio";
};
&cif_vcc_domain{
 regulator-name= "vcc18_cif";
};
&flash_vcc_domain{
 regulator-name= "vcc_flash";
};
&vccio0_vcc_domain{
 regulator-name= "vccio";
};
&vccio1_vcc_domain{
 regulator-name= "vccio";
};
&lcdc0_vcc_domain{
 regulator-name= "vcc_lcd";
};
&lcdc1_vcc_domain{
 regulator-name= "vccio";
};
