# 1 "arch/arm/boot/dts/rk3128-fireprime.dts"
# 1 "<built-in>"
# 1 "<command-line>"
# 1 "arch/arm/boot/dts/rk3128-fireprime.dts"
/dts-v1/;

# 1 "arch/arm/boot/dts/rk3128.dtsi" 1
# 1 "arch/arm/boot/dts/rk312x.dtsi" 1
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/interrupt-controller/arm-gic.h" 1







# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/interrupt-controller/irq.h" 1
# 9 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/interrupt-controller/arm-gic.h" 2
# 2 "arch/arm/boot/dts/rk312x.dtsi" 2
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/suspend/rockchip-pm.h" 1
# 3 "arch/arm/boot/dts/rk312x.dtsi" 2
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/sensor-dev.h" 1
# 4 "arch/arm/boot/dts/rk312x.dtsi" 2
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/clock/rk_system_status.h" 1
# 5 "arch/arm/boot/dts/rk312x.dtsi" 2
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/rkfb/rk_fb.h" 1
# 6 "arch/arm/boot/dts/rk312x.dtsi" 2

# 1 "arch/arm/boot/dts/skeleton.dtsi" 1






/ {
 #address-cells = <1>;
 #size-cells = <1>;
 chosen { };
 aliases { };
 memory { device_type = "memory"; reg = <0 0>; };
};
# 8 "arch/arm/boot/dts/rk312x.dtsi" 2
# 1 "arch/arm/boot/dts/rk312x-clocks.dtsi" 1
# 14 "arch/arm/boot/dts/rk312x-clocks.dtsi"
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/clock/rockchip,rk312x.h" 1



# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/clock/rockchip.h" 1
# 5 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/clock/rockchip,rk312x.h" 2
# 15 "arch/arm/boot/dts/rk312x-clocks.dtsi" 2

/{

 clocks {
  compatible = "rockchip,rk-clocks";
  #address-cells = <1>;
  #size-cells = <1>;
  ranges = <0x0 0x20000000 0x1f0>;

  fixed_rate_cons {
   compatible = "rockchip,rk-fixed-rate-cons";

   xin24m: xin24m {
    compatible = "rockchip,rk-fixed-clock";
    clock-output-names = "xin24m";
    clock-frequency = <24000000>;
    #clock-cells = <0>;
   };

   xin12m: xin12m {
    compatible = "rockchip,rk-fixed-clock";
    clocks = <&xin24m>;
    clock-output-names = "xin12m";
    clock-frequency = <12000000>;
    #clock-cells = <0>;
   };

   gmac_clkin: gmac_clkin {
    compatible = "rockchip,rk-fixed-clock";
    clock-output-names = "gmac_clkin";
    clock-frequency = <125000000>;
    #clock-cells = <0>;
   };

   usb480m: usb480m {
    compatible = "rockchip,rk-fixed-clock";
    clock-output-names = "usb480m";
    clock-frequency = <480000000>;
    #clock-cells = <0>;
   };

   i2s_clkin: i2s_clkin {
    compatible = "rockchip,rk-fixed-clock";
    clock-output-names = "i2s_clkin";
    clock-frequency = <0>;
    #clock-cells = <0>;
   };

   jtag_tck: jtag_tck {
    compatible = "rockchip,rk-fixed-clock";
    clock-output-names = "jtag_tck";
    clock-frequency = <0>;
    #clock-cells = <0>;
   };

   pclkin_cif: pclkin_cif {
    compatible = "rockchip,rk-fixed-clock";
    clock-output-names = "pclkin_cif";
    clock-frequency = <0>;
    #clock-cells = <0>;
   };

   clk_tsp_in: clk_tsp_in {
    compatible = "rockchip,rk-fixed-clock";
    clock-output-names = "clk_tsp_in";
    clock-frequency = <0>;
    #clock-cells = <0>;
   };


   dummy: dummy {
    compatible = "rockchip,rk-fixed-clock";
    clock-output-names = "dummy";
    clock-frequency = <0>;
    #clock-cells = <0>;
   };

   dummy_cpll: dummy_cpll {
    compatible = "rockchip,rk-fixed-clock";
    clock-output-names = "dummy_cpll";
    clock-frequency = <0>;
    #clock-cells = <0>;
   };

  };

  fixed_factor_cons {
   compatible = "rockchip,rk-fixed-factor-cons";

   clk_gpll_div2: clk_gpll_div2 {
    compatible = "rockchip,rk-fixed-factor-clock";
    clocks = <&clk_gpll>;
    clock-output-names = "clk_gpll_div2";
    clock-div = <2>;
    clock-mult = <1>;
    #clock-cells = <0>;
   };

   clk_gpll_div3: clk_gpll_div3 {
    compatible = "rockchip,rk-fixed-factor-clock";
    clocks = <&clk_gpll>;
    clock-output-names = "clk_gpll_div3";
    clock-div = <3>;
    clock-mult = <1>;
    #clock-cells = <0>;
   };

   g_clk_pvtm_func: g_clk_pvtm_func {
    compatible = "rockchip,rk-fixed-factor-clock";
    clocks = <&xin24m>;
    clock-output-names = "g_clk_pvtm_func";
    clock-div = <1>;
    clock-mult = <1>;
    #clock-cells = <0>;
   };

   hclk_vepu: hclk_vepu {
    compatible = "rockchip,rk-fixed-factor-clock";
    clocks = <&clk_vepu>;
    clock-output-names = "hclk_vepu";
    clock-div = <4>;
    clock-mult = <1>;
    #clock-cells = <0>;
   };

   hclk_vdpu: hclk_vdpu {
    compatible = "rockchip,rk-fixed-factor-clock";
    clocks = <&clk_vdpu>;
    clock-output-names = "hclk_vdpu";
    clock-div = <4>;
    clock-mult = <1>;
    #clock-cells = <0>;
   };

   pclkin_cif_inv: pclkin_cif_inv {
    compatible = "rockchip,rk-fixed-factor-clock";
    clocks = <&clk_gates3 3>;
    clock-output-names = "pclkin_cif_inv";
    clock-div = <1>;
    clock-mult = <1>;
    #clock-cells = <0>;
   };

   hclk_vio_niu: hclk_vio_niu {
    compatible = "rockchip,rk-fixed-factor-clock";
    clocks = <&hclk_vio_pre>;
    clock-output-names = "hclk_vio_niu";
    clock-div = <1>;
    clock-mult = <1>;
    #clock-cells = <0>;
   };

   aclk_vio0_niu: aclk_vio0_niu {
    compatible = "rockchip,rk-fixed-factor-clock";
    clocks = <&aclk_vio0_pre>;
    clock-output-names = "aclk_vio0_niu";
    clock-div = <1>;
    clock-mult = <1>;
    #clock-cells = <0>;
   };

   aclk_vio1_niu: aclk_vio1_niu {
    compatible = "rockchip,rk-fixed-factor-clock";
    clocks = <&aclk_vio1_pre>;
    clock-output-names = "aclk_vio1_niu";
    clock-div = <1>;
    clock-mult = <1>;
    #clock-cells = <0>;
   };

  };

  pd_cons {
   compatible = "rockchip,rk-pd-cons";

   pd_gpu: pd_gpu {
    compatible = "rockchip,rk-pd-clock";
    clock-output-names = "pd_gpu";
    rockchip,pd-id = <8>;
    #clock-cells = <0>;
   };

   pd_video: pd_video {
    compatible = "rockchip,rk-pd-clock";
    clock-output-names = "pd_video";
    rockchip,pd-id = <12>;
    #clock-cells = <0>;
   };

   pd_vio: pd_vio {
    compatible = "rockchip,rk-pd-clock";
    clock-output-names = "pd_vio";
    rockchip,pd-id = <13>;
    #clock-cells = <0>;
   };

   pd_vop: pd_vop {
    compatible = "rockchip,rk-pd-clock";
    clocks = <&pd_vio>;
    clock-output-names = "pd_vop";
    rockchip,pd-id = <255>;
    #clock-cells = <0>;
   };

   pd_vip: pd_vip {
    compatible = "rockchip,rk-pd-clock";
    clocks = <&pd_vio>;
    clock-output-names = "pd_vip";
    rockchip,pd-id = <255>;
    #clock-cells = <0>;
   };

   pd_iep: pd_iep {
    compatible = "rockchip,rk-pd-clock";
    clocks = <&pd_vio>;
    clock-output-names = "pd_iep";
    rockchip,pd-id = <255>;
    #clock-cells = <0>;
   };

   pd_rga: pd_rga {
    compatible = "rockchip,rk-pd-clock";
    clocks = <&pd_vio>;
    clock-output-names = "pd_rga";
    rockchip,pd-id = <255>;
    #clock-cells = <0>;
   };

   pd_ebc: pd_ebc {
    compatible = "rockchip,rk-pd-clock";
    clocks = <&pd_vio>;
    clock-output-names = "pd_ebc";
    rockchip,pd-id = <255>;
    #clock-cells = <0>;
   };

   pd_mipidsi: pd_mipidsi {
    compatible = "rockchip,rk-pd-clock";
    clocks = <&pd_vio>;
    clock-output-names = "pd_mipidsi";
    rockchip,pd-id = <255>;
    #clock-cells = <0>;
   };

   pd_hdmi: pd_hdmi {
    compatible = "rockchip,rk-pd-clock";
    clocks = <&pd_vio>;
    clock-output-names = "pd_hdmi";
    rockchip,pd-id = <255>;
    #clock-cells = <0>;
   };

  };


  clock_regs {
   compatible = "rockchip,rk-clock-regs";
   #address-cells = <1>;
   #size-cells = <1>;
   reg = <0x0000 0x01f0>;
   ranges;


   pll_cons {
    compatible = "rockchip,rk-pll-cons";
    #address-cells = <1>;
    #size-cells = <1>;
    ranges ;

    clk_apll: pll-clk@0000 {
     compatible = "rockchip,rk3188-pll-clk";
     reg = <0x0000 0x10>;
     mode-reg = <0x0040 0>;
     status-reg = <0x0004 10>;
     clocks = <&xin24m>;
     clock-output-names = "clk_apll";
     rockchip,pll-type = <(1 << (6))>;
     #clock-cells = <0>;
    };

    clk_dpll: pll-clk@0010 {
     compatible = "rockchip,rk3188-pll-clk";
     reg = <0x0010 0x10>;
     mode-reg = <0x0040 4>;
     status-reg = <0x0014 10>;
     clocks = <&xin24m>;
     clock-output-names = "clk_dpll";
     rockchip,pll-type = <(1 << (7))>;
     #clock-cells = <0>;
    };

    clk_cpll: pll-clk@0020 {
     compatible = "rockchip,rk3188-pll-clk";
     reg = <0x0020 0x10>;
     mode-reg = <0x0040 8>;
     status-reg = <0x0024 10>;
     clocks = <&xin24m>;
     clock-output-names = "clk_cpll";
     rockchip,pll-type = <(1 << (8))>;
     #clock-cells = <0>;
     #clock-init-cells = <1>;
    };

    clk_gpll: pll-clk@0030 {
     compatible = "rockchip,rk3188-pll-clk";
     reg = <0x0030 0x10>;
     mode-reg = <0x0040 12>;
     status-reg = <0x0034 10>;
     clocks = <&xin24m>;
     clock-output-names = "clk_gpll";
     rockchip,pll-type = <(1 << (7))>;
     #clock-cells = <0>;
     #clock-init-cells = <1>;
    };

   };


   clk_sel_cons {
    compatible = "rockchip,rk-sel-cons";
    #address-cells = <1>;
    #size-cells = <1>;
    ranges;

    clk_sel_con0: sel-con@0044 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0044 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_core_div: clk_core_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 5>;
      clocks = <&clk_core>;
      clock-output-names = "clk_core";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx = <11>;
      rockchip,flags = <((1 << (6)) |
         (1 << (7)))>;
     };



     clk_core: clk_core_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <7 1>;
      clocks = <&clk_apll>, <&clk_gpll_div2>;
      clock-output-names = "clk_core";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     aclk_cpu_div: aclk_cpu_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 5>;
      clocks = <&aclk_cpu>;
      clock-output-names = "aclk_cpu";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };

     aclk_cpu: aclk_cpu_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <13 2>;
      clocks = <&clk_apll>, <&clk_gpll>,<&clk_gpll_div2>,<&clk_gpll_div3>;
      clock-output-names = "aclk_cpu";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };



    };

    clk_sel_con1: sel-con@0048 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0048 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     pclk_dbg_div: pclk_dbg_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 4>;
      clocks = <&clk_core>;
      clock-output-names = "pclk_dbg";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx = <12>;
     };

     aclk_core_pre: aclk_core_pre_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <4 3>;
      clocks = <&clk_core>;
      clock-output-names = "aclk_core_pre";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx = <12>;
     };



     hclk_cpu_pre: hclk_cpu_pre_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 2>;
      clocks = <&aclk_cpu>;
      clock-output-names = "hclk_cpu_pre";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };



     pclk_cpu_pre: pclk_cpu_pre_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <12 3>;
      clocks = <&aclk_cpu>;
      clock-output-names = "pclk_cpu_pre";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };


    };

    clk_sel_con2: sel-con@004c {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x004c 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_pvtm_div: clk_pvtm_div {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <0 7>;
      clocks = <&g_clk_pvtm_func>;
      clock-output-names = "clk_pvtm";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };



     clk_nandc_div: clk_nandc_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 5>;
      clocks = <&clk_nandc>;
      clock-output-names = "clk_nandc";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
     };



     clk_nandc: clk_nandc_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <14 2>;
      clocks = <&clk_cpll>, <&clk_gpll>, <&clk_gpll_div2>;
      clock-output-names = "clk_nandc";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

    };

    clk_sel_con3: sel-con@0050 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0050 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_i2s_2ch_pll_div: clk_i2s_2ch_pll_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&clk_i2s_2ch_pll>;
      clock-output-names = "clk_i2s_2ch_pll";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };



     clk_i2s_2ch: clk_i2s_2ch_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 2>;
      clocks = <&clk_i2s_2ch_pll_div>, <&i2s_2ch_frac>, <&i2s_clkin>, <&xin12m>;
      clock-output-names = "clk_i2s_2ch";
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <14>;
      rockchip,flags = <(1 << (2))>;
     };



     clk_i2s_2ch_out: clk_i2s_2ch_out_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <12 1>;
      clocks = <&clk_i2s_2ch>, <&xin12m>;
      clock-output-names = "i2s_clkout";
      #clock-cells = <0>;
     };



     clk_i2s_2ch_pll: i2s_2ch_pll_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <14 2>;
      clocks = <&clk_cpll>,<&clk_gpll>, <&clk_gpll_div2>;
      clock-output-names = "clk_i2s_2ch_pll";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

    };

    clk_sel_con4: sel-con@0054 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0054 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_tsp_div: clk_tsp_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 5>;
      clocks = <&clk_tsp>;
      clock-output-names = "clk_tsp";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
     };



     clk_tsp: clk_tsp_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <6 2>;
      clocks = <&clk_cpll>, <&clk_gpll>, <&clk_gpll_div2>;
      clock-output-names = "clk_tsp";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     clk_24m_div: clk_24m_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 5>;
      clocks = <&xin24m>;
      clock-output-names = "clk_24m";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };



    };


    clk_sel_con5: sel-con@0058 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0058 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_mac_pll_div: clk_mac_pll_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 5>;
      clocks = <&clk_mac_pll>;
      clock-output-names = "clk_mac_pll";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      #clock-init-cells = <1>;
     };



     clk_mac_pll: clk_mac_pll_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <6 2>;
      clocks = <&clk_cpll>, <&clk_gpll>, <&clk_gpll_div2>;
      clock-output-names = "clk_mac_pll";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };



     clk_mac_ref: clk_mac_ref_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <15 1>;
      clocks = <&clk_mac_pll_div>, <&gmac_clkin>;
      clock-output-names = "clk_mac_ref";
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <10>;
      rockchip,flags = <(1 << (2))>;
      #clock-init-cells = <1>;
     };

    };


    clk_sel_con6: sel-con@005c {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x005c 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     spdif_div: spdif_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&clk_spdif_pll>;
      clock-output-names = "clk_spdif_pll";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };



     clk_spdif: spdif_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 2>;
      clocks = <&spdif_div>, <&spdif_frac>, <&xin12m>;
      clock-output-names = "clk_spdif";
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <14>;
      rockchip,flags = <(1 << (2))>;
     };



     clk_spdif_pll: spdif_pll_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <14 2>;
      clocks = <&clk_cpll>,<&clk_gpll>, <&clk_gpll_div2>;
      clock-output-names = "clk_spdif_pll";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

    };

    clk_sel_con7: sel-con@0060 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0060 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     i2s_2ch_frac: i2s_2ch_frac {
      compatible = "rockchip,rk3188-frac-con";
      clocks = <&clk_i2s_2ch_pll>;
      clock-output-names = "i2s_2ch_frac";

      rockchip,bits = <0 32>;
      rockchip,clkops-idx =
       <5>;
      #clock-cells = <0>;
     };
    };

    clk_sel_con8: sel-con@0064 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0064 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     i2s_8ch_frac: i2s_8ch_frac {
      compatible = "rockchip,rk3188-frac-con";
      clocks = <&clk_i2s_8ch_pll>;
      clock-output-names = "i2s_8ch_frac";

      rockchip,bits = <0 32>;
      rockchip,clkops-idx =
       <5>;
      #clock-cells = <0>;
     };
    };

    clk_sel_con9: sel-con@0068 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0068 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_i2s_8ch_pll_div: clk_i2s_8ch_pll_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&clk_i2s_8ch_pll>;
      clock-output-names = "clk_i2s_8ch_pll";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };



     clk_i2s_8ch: clk_i2s_8ch_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 2>;
      clocks = <&clk_i2s_8ch_pll_div>, <&i2s_8ch_frac>, <&i2s_clkin>, <&xin12m>;
      clock-output-names = "clk_i2s_8ch";
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <14>;
      rockchip,flags = <(1 << (2))>;
     };



     clk_i2s_8ch_pll: i2s_8ch_pll_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <14 2>;
      clocks = <&clk_cpll>,<&clk_gpll>, <&clk_gpll_div2>;
      clock-output-names = "clk_i2s_8ch_pll";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

    };

    clk_sel_con10: sel-con@006c {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x006c 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     aclk_peri_div: aclk_peri_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 5>;
      clocks = <&aclk_peri>;
      clock-output-names = "aclk_peri";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };



     hclk_peri_pre: hclk_peri_pre_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 2>;
      clocks = <&aclk_peri>;
      clock-output-names = "hclk_peri_pre";
      rockchip,div-type = <(1 << (7))>;
      rockchip,div-relations =
        <0x0 1
         0x1 2
         0x2 4>;
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };



     pclk_peri_pre: pclk_peri_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <12 2>;
      clocks = <&aclk_peri>;
      clock-output-names = "pclk_peri_pre";
      rockchip,div-type = <(1 << (7))>;
      rockchip,div-relations =
        <0x0 1
         0x1 2
         0x2 4
         0x3 8>;
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     aclk_peri: aclk_peri_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <14 2>;
      clocks = <&clk_gpll>,<&clk_cpll>,<&clk_gpll_div2>,<&clk_gpll_div3>;
      clock-output-names = "aclk_peri";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };
    };

    clk_sel_con11: sel-con@0070 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0070 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_sdmmc0_div: clk_sdmmc0_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 6>;
      clocks = <&clk_sdmmc0>;
      clock-output-names = "clk_sdmmc0";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <3>;
     };

     clk_sdmmc0: clk_sdmmc0_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <6 2>;
      clocks = <&clk_cpll>,<&clk_gpll>,<&clk_gpll_div2>,<&xin24m>;
      clock-output-names = "clk_sdmmc0";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     clk_sfc_div: clk_sfc_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 5>;
      clocks = <&clk_sfc>;
      clock-output-names = "clk_sfc";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <3>;
     };



     clk_sfc: clk_sfc_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <14 2>;
      clocks = <&clk_cpll>,<&clk_gpll>,<&clk_gpll_div2>,<&xin24m>;
      clock-output-names = "clk_sfc";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

    };

    clk_sel_con12: sel-con@0074 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0074 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_sdio_div: clk_sdio_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 6>;
      clocks = <&clk_sdio>;
      clock-output-names = "clk_sdio";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <3>;
     };

     clk_sdio: clk_sdio_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <6 2>;
      clocks = <&clk_cpll>,<&clk_gpll>, <&clk_gpll_div2>, <&xin24m>;
      clock-output-names = "clk_sdio";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     clk_emmc_div: clk_emmc_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 6>;
      clocks = <&clk_emmc>;
      clock-output-names = "clk_emmc";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <3>;
     };

     clk_emmc: clk_emmc_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <14 2>;
      clocks = <&clk_cpll>,<&clk_gpll>, <&clk_gpll_div2>, <&xin24m>;
      clock-output-names = "clk_emmc";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

    };

    clk_sel_con13: sel-con@0078 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0078 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_uart0_pll_div: clk_uart0_pll_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&clk_uart0_pll>;
      clock-output-names = "clk_uart0_pll";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };



     clk_uart0: clk_uart0_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 2>;
      clocks = <&clk_uart0_pll>, <&uart0_frac>, <&xin24m>;
      clock-output-names = "clk_uart0";
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <14>;
      rockchip,flags = <(1 << (2))>;
     };



     clk_uart0_pll: clk_uart0_pll_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <12 2>;
      clocks = <&clk_cpll>,<&clk_gpll>, <&clk_gpll_div2>, <&usb480m>;
      clock-output-names = "clk_uart0_pll";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     clk_uart2_pll: clk_uart2_pll_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <14 2>;
      clocks = <&clk_cpll>,<&clk_gpll>, <&clk_gpll_div2>, <&usb480m>;
      clock-output-names = "clk_uart2_pll";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

    };

    clk_sel_con14: sel-con@007c {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x007c 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_uart1_div: clk_uart1_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&clk_uart2_pll>;
      clock-output-names = "clk_uart1_div";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };



     clk_uart1: clk_uart1_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 2>;
      clocks = <&clk_uart1_div>, <&uart1_frac>, <&xin24m>;
      clock-output-names = "clk_uart1";
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <14>;
      rockchip,flags = <(1 << (2))>;
     };


    };

    clk_sel_con15: sel-con@0080 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0080 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_uart2_div: clk_uart2_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&clk_uart2_pll>;
      clock-output-names = "clk_uart2_div";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
     };



     clk_uart2: clk_uart2_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 2>;
      clocks = <&clk_uart2_div>, <&uart2_frac>, <&xin24m>;
      clock-output-names = "clk_uart2";
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <14>;
      rockchip,flags = <(1 << (2))>;
     };


    };

    clk_sel_con17: sel-con@0088 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0088 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     uart0_frac: uart0_frac {
      compatible = "rockchip,rk3188-frac-con";
      clocks = <&clk_uart0_pll>;
      clock-output-names = "uart0_frac";

      rockchip,bits = <0 32>;
      rockchip,clkops-idx =
       <5>;
      #clock-cells = <0>;
     };
    };

    clk_sel_con18: sel-con@008c {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x008c 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     uart1_frac: uart1_frac {
      compatible = "rockchip,rk3188-frac-con";
      clocks = <&clk_uart1_div>;
      clock-output-names = "uart1_frac";

      rockchip,bits = <0 32>;
      rockchip,clkops-idx =
       <5>;
      #clock-cells = <0>;
     };
    };

    clk_sel_con19: sel-con@0090 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0090 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     uart2_frac: uart2_frac {
      compatible = "rockchip,rk3188-frac-con";
      clocks = <&clk_uart2_div>;
      clock-output-names = "uart2_frac";

      rockchip,bits = <0 32>;
      rockchip,clkops-idx =
       <5>;
      #clock-cells = <0>;
     };

    };

    clk_sel_con20: sel-con@0094 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x0094 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     spdif_frac: spdif_frac {
      compatible = "rockchip,rk3188-frac-con";
      clocks = <&spdif_div>;
      clock-output-names = "spdif_frac";

      rockchip,bits = <0 32>;
      rockchip,clkops-idx =
       <5>;
      #clock-cells = <0>;
     };

    };

    clk_sel_con23: sel-con@00a0 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00a0 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     dclk_ebc: dclk_ebc_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <0 2>;
      clocks = <&clk_cpll>,<&clk_gpll>, <&clk_gpll_div2>;
      clock-output-names = "dclk_ebc";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };



     dclk_ebc_div: dclk_ebc_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 8>;
      clocks = <&dclk_ebc>;
      clock-output-names = "dclk_ebc";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
     };

    };

    clk_sel_con24: sel-con@00a4 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00a4 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_crypto_div: clk_crypto_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 2>;
      clocks = <&aclk_cpu>;
      clock-output-names = "clk_crypto";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };



     clk_saradc: clk_saradc_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 8>;
      clocks = <&xin24m>;
      clock-output-names = "clk_saradc";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

    };

    clk_sel_con25: sel-con@00a8 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00a8 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_spi0_div: clk_spi0_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 7>;
      clocks = <&clk_spi0>;
      clock-output-names = "clk_spi0";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
     };



     clk_spi0: clk_spi0_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 2>;
      clocks = <&clk_cpll>, <&clk_gpll>,<&clk_gpll_div2>;
      clock-output-names = "clk_spi0";
      #clock-cells = <0>;
     };



    };

    clk_sel_con26: sel-con@00ac {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00ac 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     ddr_div: ddr_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 2>;
      clocks = <&clk_ddr>;
      clock-output-names = "clk_ddr";
      rockchip,div-type = <(1 << (7))>;
      rockchip,div-relations =
        <0x0 1
         0x1 2
         0x3 4>;
      #clock-cells = <0>;
      rockchip,flags = <((1 << (6)) |
         (1 << (7)))>;
      rockchip,clkops-idx = <18>;
     };



     clk_ddr: ddr_clk_pll_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <8 1>;
      clocks = <&clk_dpll>, <&dummy>;
      clock-output-names = "clk_ddr";
      #clock-cells = <0>;
     };


    };

    clk_sel_con27: sel-con@00b0 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00b0 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     dclk_lcdc0: dclk_lcdc0_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <0 2>;
      clocks = <&clk_cpll>, <&clk_gpll>, <&clk_gpll_div2>, <&clk_gpll_div3>;
      clock-output-names = "dclk_lcdc0";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };



     dclk_lcdc0_div: dclk_lcdc0_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 8>;
      clocks = <&dclk_lcdc0>;
      clock-output-names = "dclk_lcdc0";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };
    };

    clk_sel_con28: sel-con@00b4 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00b4 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     sclk_lcdc0: sclk_lcdc0_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <0 2>;
      clocks = <&clk_cpll>, <&clk_gpll>, <&clk_gpll_div2>, <&clk_gpll_div3>;
      clock-output-names = "sclk_lcdc0";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };



     sclk_lcdc0_div: sclk_lcdc0_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 8>;
      clocks = <&sclk_lcdc0>;
      clock-output-names = "sclk_lcdc0";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };
    };

    clk_sel_con29: sel-con@00b8 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00b8 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_cif_pll: clk_cif_pll_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <0 2>;
      clocks = <&clk_cpll>, <&clk_gpll>, <&clk_gpll_div2>, <&usb480m>;
      clock-output-names = "clk_cif_pll";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     clk_cif_out_div: clk_cif_out_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <2 5>;
      clocks = <&clk_cif_out>;
      clock-output-names = "clk_cif_out";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
     };

     clk_cif_out: clk_cif_out_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <7 1>;
      clocks = <&clk_cif_pll>, <&xin24m>;
      clock-output-names = "clk_cif_out";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     pclk_pmu_pre: pclk_pmu_pre_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 6>;
      clocks = <&clk_cpll>;
      clock-output-names = "pclk_pmu_pre";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };


    };

    clk_sel_con30: sel-con@00bc {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00bc 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_testout_div: clk_testout_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 5>;
      clocks = <&dummy>;
      clock-output-names = "clk_testout";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };



     clk_cif0_in: clk_cif0_in_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <7 1>;
      clocks = <&pclkin_cif>, <&pclkin_cif_inv>;
      clock-output-names = "clk_cif0_in";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     hclk_vio_pre_div: hclk_vio_pre_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 5>;
      clocks = <&hclk_vio_pre>;
      clock-output-names = "hclk_vio_pre";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };



     hclk_vio_pre: hclk_vio_pre_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <14 2>;
      clocks = <&clk_cpll>, <&clk_gpll>, <&clk_gpll_div2>, <&usb480m>;
      clock-output-names = "hclk_vio_pre";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

    };

    clk_sel_con31: sel-con@00c0 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00c0 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     aclk_vio0_pre_div: aclk_vio0_pre_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 5>;
      clocks = <&aclk_vio0_pre>;
      clock-output-names = "aclk_vio0_pre";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };

     aclk_vio0_pre: aclk_vio0_pre_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <5 3>;
      clocks = <&clk_cpll>, <&clk_gpll>, <&clk_gpll_div2>, <&clk_gpll_div3>, <&usb480m>;
      clock-output-names = "aclk_vio0_pre";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     aclk_vio1_pre_div: aclk_vio1_pre_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 5>;
      clocks = <&aclk_vio1_pre>;
      clock-output-names = "aclk_vio1_pre";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };

     aclk_vio1_pre: aclk_vio1_pre_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <13 3>;
      clocks = <&clk_cpll>, <&clk_gpll>, <&clk_gpll_div2>, <&clk_gpll_div3>, <&usb480m>;
      clock-output-names = "aclk_vio1_pre";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

    };

    clk_sel_con32: sel-con@00c4 {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00c4 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_vepu_div: clk_vepu_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 5>;
      clocks = <&clk_vepu>;
      clock-output-names = "clk_vepu";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };

     clk_vepu: clk_vepu_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <5 3>;
      clocks = <&clk_cpll>, <&clk_gpll>, <&clk_gpll_div2>, <&clk_gpll_div3>, <&usb480m>;
      clock-output-names = "clk_vepu";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     clk_vdpu_div: clk_vdpu_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 5>;
      clocks = <&clk_vdpu>;
      clock-output-names = "clk_vdpu";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };

     clk_vdpu: clk_vdpu_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <13 3>;
      clocks = <&clk_cpll>, <&clk_gpll>, <&clk_gpll_div2>, <&clk_gpll_div3>, <&usb480m>;
      clock-output-names = "clk_vdpu";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

    };

    clk_sel_con34: sel-con@00cc {
     compatible = "rockchip,rk3188-selcon";
     reg = <0x00cc 0x4>;
     #address-cells = <1>;
     #size-cells = <1>;

     clk_gpu_div: clk_gpu_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <0 5>;
      clocks = <&clk_gpu>;
      clock-output-names = "clk_gpu";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (8))>;
     };

     clk_gpu: clk_gpu_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <5 3>;
      clocks = <&clk_cpll>, <&clk_gpll>, <&clk_gpll_div2>, <&clk_gpll_div3>, <&usb480m>;
      clock-output-names = "clk_gpu";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

     clk_hevc_core_div: clk_hevc_core_div {
      compatible = "rockchip,rk3188-div-con";
      rockchip,bits = <8 5>;
      clocks = <&clk_hevc_core>;
      clock-output-names = "clk_hevc_core";
      rockchip,div-type = <(0)>;
      #clock-cells = <0>;
      rockchip,clkops-idx =
       <1>;
      rockchip,flags = <(1 << (7))>;
     };

     clk_hevc_core: clk_hevc_core_mux {
      compatible = "rockchip,rk3188-mux-con";
      rockchip,bits = <13 3>;
      clocks = <&clk_cpll>, <&clk_gpll>, <&clk_gpll_div2>, <&clk_gpll_div3>, <&usb480m>;
      clock-output-names = "clk_hevc_core";
      #clock-cells = <0>;
      #clock-init-cells = <1>;
     };

    };

   };



   clk_gate_cons {
    compatible = "rockchip,rk-gate-cons";
    #address-cells = <1>;
    #size-cells = <1>;
    ranges ;

    clk_gates0: gate-clk@00d0{
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00d0 0x4>;
     clocks =
      <&clk_core>, <&dummy>,
      <&dummy>, <&aclk_cpu>,

      <&aclk_cpu>, <&aclk_cpu>,
      <&dummy>, <&clk_core>,

      <&dummy>, <&clk_i2s_2ch_pll>,
      <&i2s_2ch_frac>, <&hclk_vio_pre>,

      <&aclk_cpu>, <&clk_i2s_2ch_out>,
      <&clk_i2s_2ch>, <&dummy>;

     clock-output-names =
      "pclk_dbg", "aclk_cpu",
      "reserved", "aclk_cpu_pre",

      "hclk_cpu_pre", "pclk_cpu_pre",
      "clk_core", "aclk_core_pre",

      "reserved", "clk_i2s_2ch_pll",
      "i2s_2ch_frac", "hclk_vio_pre",

      "clk_crypto", "clk_i2s_2ch_out",
      "clk_i2s_2ch", "clk_testout";
     rockchip,suspend-clkgating-setting=<0x11ff 0x0>;

     #clock-cells = <1>;
    };

    clk_gates1: gate-clk@00d4{
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00d4 0x4>;
     clocks =
      <&clk_cpll>, <&dummy>,
      <&dummy>, <&jtag_tck>,

      <&aclk_vio1_pre>, <&xin12m>,
      <&xin12m>, <&clk_mac_pll>,

      <&clk_uart0_pll>, <&uart0_frac>,
      <&clk_uart1_div>, <&uart1_frac>,

      <&clk_uart2_div>, <&uart2_frac>,
      <&clk_tsp>, <&dummy>;

     clock-output-names =
      "pclk_pmu_pre", "reserved",
      "reserved", "clk_jtag",

      "aclk_vio1_pre", "clk_otgphy0",
      "clk_otgphy1", "clk_mac_pll",

      "clk_uart0_pll", "uart0_frac",
      "clk_uart1_div", "uart1_frac",

      "clk_uart2_div", "uart2_frac",
      "clk_tsp", "reserved";

      rockchip,suspend-clkgating-setting=<0x000f 0x0>;
     #clock-cells = <1>;
    };

    clk_gates2: gate-clk@00d8 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00d8 0x4>;
     clocks =
      <&aclk_peri>, <&aclk_peri>,
      <&aclk_peri>, <&aclk_peri>,

      <&clk_mac_ref>, <&clk_mac_ref>,
      <&clk_mac_ref>, <&clk_mac_ref>,

      <&clk_saradc>, <&clk_spi0>,
      <&clk_spdif_pll>, <&clk_sdmmc0>,

      <&spdif_frac>, <&clk_sdio>,
      <&clk_emmc>, <&xin24m>;
     clock-output-names =
      "aclk_peri", "aclk_peri_pre",
      "hclk_peri_pre", "pclk_peri_pre",

      "clk_mac_ref", "clk_mac_refout",
      "clk_mac_rx", "clk_mac_tx",

      "clk_saradc", "clk_spi0",
      "clk_spdif_pll", "clk_sdmmc0",

      "spdif_frac", "clk_sdio",
      "clk_emmc", "clk_mipi_24m";
         rockchip,suspend-clkgating-setting=<0x000f 0x0>;

     #clock-cells = <1>;
    };

    clk_gates3: gate-clk@00dc {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00dc 0x4>;
     clocks =
      <&aclk_vio0_pre>, <&dclk_lcdc0>,
      <&sclk_lcdc0>, <&pclkin_cif>,

      <&dclk_ebc>, <&hclk_cpu_pre>,
      <&hclk_peri_pre>, <&clk_cif_pll>,

      <&pclk_cpu_pre>, <&clk_vepu>,
      <&clk_hevc_core>, <&clk_vdpu>,

      <&hclk_vdpu>, <&clk_gpu>,
      <&aclk_peri>, <&clk_sfc>;

     clock-output-names =
      "aclk_vio0_pre", "dclk_lcdc0",
      "sclk_lcdc0", "pclkin_cif",

      "dclk_ebc", "g_hclk_crypto",
      "g_hclk_em_peri", "clk_cif_pll",

      "g_pclk_hdmi", "clk_vepu",
      "clk_hevc_core", "clk_vdpu",

      "hclk_vdpu", "clk_gpu",
      "g_hclk_gps", "clk_sfc";
                                       rockchip,suspend-clkgating-setting=<0x0060 0x0000>;

     #clock-cells = <1>;
    };

    clk_gates4: gate-clk@00e0{
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00e0 0x4>;
     clocks =
      <&hclk_peri_pre>, <&pclk_peri_pre>,
      <&aclk_peri>, <&aclk_peri>,

      <&clk_i2s_8ch_pll>, <&i2s_8ch_frac>,
      <&clk_i2s_8ch>, <&dummy>,

      <&dummy>, <&dummy>,
      <&aclk_cpu>, <&dummy>,

      <&aclk_cpu>, <&dummy>,
      <&dummy>, <&dummy>;

     clock-output-names =
      "g_hp_axi_matrix", "g_pp_axi_matrix",
      "g_aclk_cpu_peri", "g_ap_axi_matrix",

      "clk_i2s_8ch_pll", "i2s_8ch_frac",
      "clk_i2s_8ch", "reserved",

      "reserved", "reserved",
      "g_aclk_strc_sys", "reserved",


      "g_aclk_intmem", "reserved",
      "reserved", "reserved";

     rockchip,suspend-clkgating-setting = <0xff8f 0x0000>;
     #clock-cells = <1>;
    };

    clk_gates5: gate-clk@00e4 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00e4 0x4>;
     clocks =
      <&pclk_cpu_pre>, <&aclk_peri>,
      <&pclk_peri_pre>, <&dummy>,

      <&pclk_cpu_pre>, <&dummy>,
      <&hclk_cpu_pre>, <&pclk_cpu_pre>,

      <&dummy>, <&hclk_peri_pre>,
      <&hclk_peri_pre>, <&hclk_peri_pre>,

      <&dummy>, <&hclk_peri_pre>,
      <&pclk_cpu_pre>, <&dummy>;

     clock-output-names =
      "g_pclk_mipiphy", "g_aclk_dmac",
      "g_pclk_efuse", "reserved",

      "g_pclk_grf", "reserved",
      "g_hclk_rom", "g_pclk_ddrupctl",

      "reserved", "g_hclk_nandc",
      "g_hclk_sdmmc0", "g_hclk_sdio",

      "reserved", "g_hclk_otg0",
      "g_pclk_acodec", "reserved";

     rockchip,suspend-clkgating-setting = <0x00f0 0x0000>;

     #clock-cells = <1>;
    };

    clk_gates6: gate-clk@00e8 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00e8 0x4>;
     clocks =
      <&aclk_vio0_niu>, <&hclk_vio_niu>,
      <&dummy>, <&dummy>,

      <&hclk_vio_niu>, <&aclk_vio0_niu>,
      <&dummy>, <&dummy>,

      <&dummy>, <&dummy>,
      <&hclk_vio_niu>, <&aclk_vio0_niu>,

      <&hclk_vio_pre>, <&aclk_vio0_pre>,
      <&dummy>, <&dummy>;

     clock-output-names =
      "g_aclk_lcdc0", "g_hclk_lcdc0",
      "reserved", "reserved",

      "g_hclk_cif", "g_aclk_cif",
      "reserved", "reserved",

      "reserved", "reserved",
      "g_hclk_rga", "g_aclk_rga",

      "hclk_vio_niu", "aclk_vio0_niu",
      "reserved", "reserved";

     rockchip,suspend-clkgating-setting = <0x0000 0x0000>;

     #clock-cells = <1>;
    };

    clk_gates7: gate-clk@00ec {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00ec 0x4>;
     clocks =
      <&hclk_peri_pre>, <&hclk_peri_pre>,
      <&hclk_peri_pre>, <&hclk_peri_pre>,

      <&hclk_peri_pre>, <&dummy>,
      <&dummy>, <&pclk_peri_pre>,

      <&dummy>, <&dummy>,
      <&pclk_peri_pre>, <&dummy>,

      <&pclk_peri_pre>, <&dummy>,
      <&pclk_peri_pre>, <&pclk_peri_pre>;

     clock-output-names =
      "g_hclk_emmc", "g_hclk_sfc",
      "g_hclk_i2s_2ch", "g_hclk_host",

      "g_hclk_i2s_8ch", "reserved",
      "reserved", "g_pclk_timer",

      "reserved", "reserved",
      "g_pclk_pwm", "reserved",

      "g_pclk_spi0", "reserved",
      "g_pclk_saradc", "g_pclk_wdt";

     rockchip,suspend-clkgating-setting = <0x8480 0x0000>;

     #clock-cells = <1>;
    };

    clk_gates8: gate-clk@00f0 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00f0 0x4>;
     clocks =
      <&pclk_peri_pre>, <&pclk_peri_pre>,
      <&pclk_peri_pre>, <&dummy>,

      <&pclk_peri_pre>, <&pclk_peri_pre>,
      <&pclk_peri_pre>, <&pclk_peri_pre>,

      <&dummy>, <&pclk_peri_pre>,
      <&pclk_peri_pre>, <&pclk_peri_pre>,

      <&pclk_peri_pre>, <&dummy>,
      <&dummy>, <&dummy>;

     clock-output-names =
      "g_pclk_uart0", "g_pclk_uart1",
      "g_pclk_uart2", "reserved",

      "g_pclk_i2c0", "g_pclk_i2c1",
      "g_pclk_i2c2", "g_pclk_i2c3",

      "reserved", "g_pclk_gpio0",
      "g_pclk_gpio1", "g_pclk_gpio2",

      "g_pclk_gpio3", "reserved",
      "reserved", "reserved";

                                        rockchip,suspend-clkgating-setting=<0xff0f 0x0000>;
     #clock-cells = <1>;
    };

    clk_gates9: gate-clk@00f4 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00f4 0x4>;
     clocks =
      <&dummy>, <&dummy>,
      <&pclk_pmu_pre>, <&pclk_pmu_pre>,

      <&dummy>, <&hclk_vio_niu>,
      <&hclk_vio_niu>, <&hclk_vio_niu>,

      <&aclk_vio1_niu>, <&hclk_vio_niu>,
      <&aclk_vio1_pre>, <&dummy>,

      <&pclk_peri_pre>, <&hclk_peri_pre>,
      <&hclk_peri_pre>, <&aclk_peri>;

     clock-output-names =
      "reserved", "reserved",
      "g_pclk_pmu", "g_pclk_pmu_noc",

      "reserved", "g_hclk_vio_h2p",
      "g_pclk_mipi", "g_hclk_iep",

      "g_aclk_iep", "g_hclk_ebc",
      "aclk_vio1_niu", "reserved",

      "g_pclk_sim_card", "g_hclk_usb_peri",
      "g_hclk_pe_arbi", "g_aclk_peri_niu";

     rockchip,suspend-clkgating-setting=<0xf00f 0x0>;

     #clock-cells = <1>;
    };

    clk_gates10: gate-clk@00f8 {
     compatible = "rockchip,rk3188-gate-clk";
     reg = <0x00f8 0x4>;
     clocks =
      <&xin24m>, <&xin24m>,
      <&xin24m>, <&xin24m>,

      <&xin24m>, <&xin24m>,
      <&xin24m>, <&xin24m>,

      <&xin24m>, <&hclk_peri_pre>,
      <&aclk_peri>, <&pclk_peri_pre>,

      <&hclk_peri_pre>, <&clk_tsp_in>,
      <&hclk_peri_pre>, <&clk_nandc>;

     clock-output-names =
      "g_clk_pvtm_core", "g_clk_pvtm_gpu",
      "g_clk_pvtm_func", "clk_timer0",

      "clk_timer1", "clk_timer2",
      "clk_timer3", "clk_timer4",

      "clk_timer5", "g_hclk_spdif",
      "g_aclk_gmac", "g_pclk_gmac",

      "g_hclk_tsp", "g_clkin0_tsp",
      "g_hclk_usbhost", "clk_nandc";

     rockchip,suspend-clkgating-setting = <0x0000 0x0>;

     #clock-cells = <1>;
    };

   };
  };
 };
};
# 9 "arch/arm/boot/dts/rk312x.dtsi" 2
# 1 "arch/arm/boot/dts/rk312x-pinctrl.dtsi" 1

# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/gpio/gpio.h" 1
# 3 "arch/arm/boot/dts/rk312x-pinctrl.dtsi" 2
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/pinctrl/rockchip.h" 1
# 4 "arch/arm/boot/dts/rk312x-pinctrl.dtsi" 2
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/pinctrl/rockchip-rk312x.h" 1
# 5 "arch/arm/boot/dts/rk312x-pinctrl.dtsi" 2

/ {
 pinctrl: pinctrl@20008000 {
  compatible = "rockchip,rk312x-pinctrl";
  reg = <0x20008000 0xA8>,
        <0x200080A8 0x4C>,
        <0x20008118 0x20>,
        <0x20008100 0x04>;
  reg-names = "base", "mux", "pull", "drv";
  #address-cells = <1>;
  #size-cells = <1>;
  ranges;

  gpio0: gpio0@2007c000 {
   compatible = "rockchip,gpio-bank";
   reg = <0x2007c000 0x100>;
   interrupts = <0 36 4>;
   clocks = <&clk_gates8 9>;

   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpio1: gpio1@20080000 {
   compatible = "rockchip,gpio-bank";
   reg = <0x20080000 0x100>;
   interrupts = <0 37 4>;
   clocks = <&clk_gates8 10>;

   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpio2: gpio2@20084000 {
   compatible = "rockchip,gpio-bank";
   reg = <0x20084000 0x100>;
   interrupts = <0 38 4>;
   clocks = <&clk_gates8 11>;

   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpio3: gpio3@20088000 {
   compatible = "rockchip,gpio-bank";
   reg = <0x20088000 0x100>;
   interrupts = <0 39 4>;
   clocks = <&clk_gates8 12>;

   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  gpio15: gpio15@2008A000 {
   compatible = "rockchip,gpio-bank";
   reg = <0x20086000 0x100>;
   interrupts = <0 127 4>;
   clocks = <&clk_gates8 12>;

   gpio-controller;
   #gpio-cells = <2>;

   interrupt-controller;
   #interrupt-cells = <2>;
  };

  pcfg_pull_up: pcfg_pull_up {
   bias-pull-up;
  };

  pcfg_pull_down: pcfg_pull_down {
   bias-pull-down;
  };

  pcfg_pull_none: pcfg_pull_none {
   bias-disable;
  };

  gpio0_uart0 {
   uart0_xfer: uart0-xfer {
    rockchip,pins = <0x2d32>,
      <0x2d22>;
    rockchip,pull = <0>;


   };

   uart0_cts: uart0-cts {
    rockchip,pins = <0x2d52>;
    rockchip,pull = <4>;


   };

   uart0_rts: uart0-rts {
    rockchip,pins = <0x0c12>;
    rockchip,pull = <4>;


   };

   uart0_rts_gpio: uart0-rts-gpio {
    rockchip,pins = <((0x0c12) & 0xfff0)>;
    rockchip,pull = <4>;

   };
  };

  gpio1_uart1 {
   uart1_xfer: uart1-xfer {
    rockchip,pins = <0x1b22>,
      <0x1b12>;
    rockchip,pull = <4>;


   };

   uart1_cts: uart1-cts {
    rockchip,pins = <0x1b02>;
    rockchip,pull = <4>;


   };

   uart1_rts: uart1-rts {
    rockchip,pins = <0x1b32>;
    rockchip,pull = <4>;


   };

   uart1_rts_gpio: uart1-rts-gpio {
    rockchip,pins = <((0x1b32) & 0xfff0)>;
    rockchip,pull = <4>;

   };
  };

  gpio1_uart2 {
   uart2_xfer: uart2-xfer {
    rockchip,pins = <0x1c32>,
      <0x1c22>;
    rockchip,pull = <4>;


   };

   uart2_cts: uart2-cts {
    rockchip,pins = <0x0d11>;
    rockchip,pull = <4>;


   };

   uart2_rts: uart2-rts {
    rockchip,pins = <0x0d01>;
    rockchip,pull = <4>;


   };

   uart2_rts_gpio: uart2-rts-gpio {
    rockchip,pins = <((0x0d01) & 0xfff0)>;
    rockchip,pull = <4>;

   };
  };


  gpio0_i2c0 {
   i2c0_sda:i2c0-sda {
    rockchip,pins = <0x0a11>;
    rockchip,pull = <4>;


   };

   i2c0_scl:i2c0-scl {
    rockchip,pins = <0x0a01>;
    rockchip,pull = <4>;


   };

   i2c0_gpio: i2c0-gpio {
    rockchip,pins = <((0x0a11) & 0xfff0)>, <((0x0a01) & 0xfff0)>;
    rockchip,pull = <4>;

   };
  };

  gpio0_i2c1 {
   i2c1_sda:i2c1-sda {
    rockchip,pins = <0x0a31>;
    rockchip,pull = <4>;


   };

   i2c1_scl:i2c1-scl {
    rockchip,pins = <0x0a21>;
    rockchip,pull = <4>;


   };

   i2c1_gpio: i2c1-gpio {
    rockchip,pins = <((0x0a31) & 0xfff0)>, <((0x0a21) & 0xfff0)>;
    rockchip,pull = <4>;

   };
  };

  gpio1_i2c2 {
   i2c2_sda:i2c2-sda {
    rockchip,pins = <0x2c43>;
    rockchip,pull = <4>;


   };

   i2c2_scl:i2c2-scl {
    rockchip,pins = <0x2c53>;
    rockchip,pull = <4>;


   };

   i2c2_gpio: i2c2-gpio {
    rockchip,pins = <((0x2c43) & 0xfff0)>, <((0x2c53) & 0xfff0)>;
    rockchip,pull = <4>;

   };
  };


  gpio0_i2c3 {
   i2c3_sda:i2c3-sda {
    rockchip,pins = <0x0a71>;
    rockchip,pull = <4>;


   };

   i2c3_scl:i2c3-scl {
    rockchip,pins = <0x0a61>;
    rockchip,pull = <4>;


   };

   i2c3_gpio: i2c3-gpio {
    rockchip,pins = <((0x0a71) & 0xfff0)>, <((0x0a61) & 0xfff0)>;
    rockchip,pull = <4>;

   };
  };



  gpio1_spi0 {
   spi0_txd_mux0:spi0-txd-mux0 {
    rockchip,pins = <0x1b11>;
    rockchip,pull = <4>;

   };

   spi0_rxd_mux0:spi0-rxd-mux0 {
    rockchip,pins = <0x1b21>;
    rockchip,pull = <4>;

   };

   spi0_clk_mux0:spi0-clk-mux0 {
    rockchip,pins = <0x1b01>;
    rockchip,pull = <4>;

   };

   spi0_cs0_mux0:spi0-cs0-mux0 {
    rockchip,pins = <0x1b31>;
    rockchip,pull = <4>;

   };

   spi0_cs1_mux0:spi0-cs1-mux0 {
    rockchip,pins = <0x1b41>;
    rockchip,pull = <4>;

   };



   spi0_txd_mux1:spi0-txd-mux1 {
    rockchip,pins = <0x1d53>;
    rockchip,pull = <4>;

   };

   spi0_rxd_mux1:spi0-rxd-mux1 {
    rockchip,pins = <0x1d43>;
    rockchip,pull = <4>;

   };

   spi0_clk_mux1:spi0-clk-mux1 {
    rockchip,pins = <0x2a02>;
    rockchip,pull = <4>;

   };

   spi0_cs0_mux1:spi0-cs0-mux1 {
    rockchip,pins = <0x1d63>;
    rockchip,pull = <4>;

   };

   spi0_cs1_mux1:spi0-cs1-mux1 {
    rockchip,pins = <0x1d73>;
    rockchip,pull = <4>;

   };



   spi0_txd_mux2:spi0-txd-mux2 {
    rockchip,pins = <0x0b32>;
    rockchip,pull = <4>;

   };

   spi0_rxd_mux2:spi0-rxd-mux2 {
    rockchip,pins = <0x0b52>;
    rockchip,pull = <4>;

   };

   spi0_clk_mux2:spi0-clk-mux2 {
    rockchip,pins = <0x0b12>;
    rockchip,pull = <4>;

   };

   spi0_cs0_mux2:spi0-cs0-mux2 {
    rockchip,pins = <0x0b62>;
    rockchip,pull = <4>;

   };

  };

  gpio1_hdmi {
   hdmi_cec:hdmi-cec {
    rockchip,pins = <0x0c41>;
    rockchip,pull = <4>;

   };

   hdmi_sda:hdmi-sda {
    rockchip,pins = <0x0a72>;
    rockchip,pull = <4>;

   };

   hdmi_scl:hdmi-scl {
    rockchip,pins = <0x0a62>;
    rockchip,pull = <4>;

   };

   hdmi_hpd:hdmi-hpd {
    rockchip,pins = <0x0b71>;
    rockchip,pull = <4>;


   };

   hdmi_gpio: hdmi-gpio {
    rockchip,pins = <((0x0c41) & 0xfff0)>, <((0x0a72) & 0xfff0)>, <((0x0a62) & 0xfff0)>, <((0x0b71) & 0xfff0)>;
    rockchip,pull = <4>;

   };
  };

  gpio1_i2s0 {
   i2s0_mclk_mux0:i2s0-mclk-mux0 {
    rockchip,pins = <0x0b01>;
    rockchip,pull = <4>;

   };

   i2s0_sclk_mux0:i2s0-sclk-mux0 {
    rockchip,pins = <0x0b11>;
    rockchip,pull = <4>;

   };

   i2s0_lrckrx_mux0:i2s0-lrckrx-mux0 {
    rockchip,pins = <0x0b31>;
    rockchip,pull = <4>;

   };

   i2s0_lrcktx_mux0:i2s0-lrcktx-mux0 {
    rockchip,pins = <0x0b41>;
    rockchip,pull = <4>;

   };

   i2s0_sdo_mux0:i2s0-sdo-mux0 {
    rockchip,pins = <0x0b51>;
    rockchip,pull = <4>;

   };

   i2s0_sdi_mux0:i2s0-sdi-mux0 {
    rockchip,pins = <0x0b61>;
    rockchip,pull = <4>;

   };

   i2s0_gpio_mux0: i2s0-gpio-mux0 {
    rockchip,pins = <((0x0b01) & 0xfff0)>,
      <((0x0b11) & 0xfff0)>,
      <((0x0b31) & 0xfff0)>,
      <((0x0b41) & 0xfff0)>,
      <((0x0b51) & 0xfff0)>,
      <((0x0b61) & 0xfff0)>;
    rockchip,pull = <4>;

   };


   i2s0_mclk_mux1:i2s0-mclk-mux1 {
    rockchip,pins = <0x1a01>;
    rockchip,pull = <4>;

   };

   i2s0_sclk_mux1:i2s0-sclk-mux1 {
    rockchip,pins = <0x1a11>;
    rockchip,pull = <4>;

   };

   i2s0_lrckrx_mux1:i2s0-lrckrx-mux1 {
    rockchip,pins = <0x1a21>;
    rockchip,pull = <4>;

   };

   i2s0_lrcktx_mux1:i2s0-lrcktx-mux1 {
    rockchip,pins = <0x1a31>;
    rockchip,pull = <4>;

   };

   i2s0_sdo_mux1:i2s0-sdo-mux1 {
    rockchip,pins = <0x1a41>;
    rockchip,pull = <4>;

   };

   i2s0_sdi_mux1:i2s0-sdi-mux1 {
    rockchip,pins = <0x1a51>;
    rockchip,pull = <4>;

   };

   i2s0_gpio_mux1: i2s0-gpio-mux1 {
    rockchip,pins = <((0x1a01) & 0xfff0)>,
      <((0x1a11) & 0xfff0)>,
      <((0x1a21) & 0xfff0)>,
      <((0x1a31) & 0xfff0)>,
      <((0x1a41) & 0xfff0)>,
      <((0x1a51) & 0xfff0)>;
    rockchip,pull = <4>;

   };

  };

  gpio0_spdif {
   spdif_tx: spdif-tx {
    rockchip,pins = <0x3d31>;
    rockchip,pull = <4>;

   };
  };

  gpio0_emmc0 {
   emmc0_clk: emmc0-clk {
    rockchip,pins = <0x2a72>;
    rockchip,pull = <4>;


   };

   emmc0_cmd_mux0: emmc0-cmd-mux0 {
    rockchip,pins = <0x1c62>;
    rockchip,pull = <1>;


   };

   emmc0_cmd_mux1: emmc0-cmd-mux1 {
    rockchip,pins = <0x2a42>;
    rockchip,pull = <1>;


   };


   emmc0_bus1: emmc0-bus-width1 {
    rockchip,pins = <0x1d02>;
    rockchip,pull = <1>;


   };

   emmc0_bus4: emmc0-bus-width4 {
    rockchip,pins = <0x1d02>,
             <0x1d12>,
             <0x1d22 >,
             <0x1d32>;
    rockchip,pull = <1>;


   };
  };

  gpio1_sdmmc0 {
   sdmmc0_clk: sdmmc0-clk {
    rockchip,pins = <0x1c01>;
    rockchip,pull = <4>;


   };

   sdmmc0_cmd: sdmmc0-cmd {
    rockchip,pins = <0x1b71>;
    rockchip,pull = <1>;

   };

   sdmmc0_dectn: sdmmc0-dectn{
    rockchip,pins = <0x1c11>;
    rockchip,pull = <1>;


   };

   sdmmc0_pwren: sdmmc0-pwren{
    rockchip,pins = <0x1b61>;
    rockchip,pull = <1>;
   };

   sdmmc0_bus1: sdmmc0-bus-width1 {
    rockchip,pins = <0x1c21>;
    rockchip,pull = <1>;


   };

   sdmmc0_bus4: sdmmc0-bus-width4 {
    rockchip,pins = <0x1c21>,
      <0x1c31>,
      <0x1c41>,
      <0x1c51>;
    rockchip,pull = <1>;


   };

   sdmmc0_gpio: sdmmc0_gpio{
    rockchip,pins =
     <0x1b70>,
     <0x1c00>,
     <0x1c10>,
     <0x1b60>,
     <0x1c20>,
     <0x1c30>,
     <0x1c40>,
     <0x1c50>;
    rockchip,pull = <1>;


   };

  };

  gpio2_nandc {
   nandc_ale:nandc-ale {
    rockchip,pins = <0x2a01>;
    rockchip,pull = <4>;
   };

   nandc_cle:nandc-cle {
    rockchip,pins = <0x2a11>;
    rockchip,pull = <4>;
   };

   nandc_wrn:nandc-wrn {
    rockchip,pins = <0x2a21>;
    rockchip,pull = <4>;
   };

   nandc_rdn:nandc-rdn {
    rockchip,pins = <0x2a31>;
    rockchip,pull = <4>;
   };

   nandc_rdy:nandc-rdy {
    rockchip,pins = <0x2a41>;
    rockchip,pull = <4>;
   };

   nandc_cs0:nandc-cs0 {
    rockchip,pins = <0x2a61>;
    rockchip,pull = <4>;
   };


   nandc_data: nandc-data {
    rockchip,pins = <0x1d01>,
      <0x1d11>,
      <0x1d21>,
      <0x1d31>,
      <0x1d41>,
      <0x1d51>,
      <0x1d61>,
      <0x1d71>;
    rockchip,pull = <4>;

   };

  };

  gpio0_sdio0 {
   sdio0_pwren: sdio0_pwren {
    rockchip,pins = <((0x0d61) & 0xfff0)>;
    rockchip,pull = <4>;


   };

   sdio0_cmd: sdio0_cmd {
    rockchip,pins = <0x0a32>;
    rockchip,pull = <4>;
   };
   sdio0_clk: sdio0_clk {
    rockchip,pins = <0x1a02>;
    rockchip,pull = <4>;
   };
   sdio0_bus1: sdio0-bus-width1 {
    rockchip,pins = <0x1a12>;
    rockchip,pull = <4>;
   };
   sdio0_bus4: sdio0-bus-width4 {
    rockchip,pins = <0x1a12>,
      <0x1a22>,
      <0x1a42>,
      <0x1a52>;
    rockchip,pull = <4>;
   };

   sdio0_gpio: sdio0_gpio{
    rockchip,pins = <0x0d60>,
      <0x0a30>,
      <0x1a00>,
      <0x1a10>,
      <0x1a20>,
      <0x1a40>,
      <0x1a50>;
    rockchip,pull = <4>;
   };

  };

  gpio0_pwm{
   pwm0_pin:pwm0 {
    rockchip,pins = <0x0d21>;
    rockchip,pull = <4>;


   };

   pwm1_pin:pwm1 {
    rockchip,pins = <((0x0d31) & 0xfff0)>;
    rockchip,pull = <0>;


   };

   pwm2_pin:pwm2 {
    rockchip,pins = <0x0d41>;
    rockchip,pull = <4>;


   };

   pwm3_pin:pwm3 {
    rockchip,pins = <0x3d21>;
    rockchip,pull = <4>;


   };
  };

  gpio2_gmac {
   gmac_rxdv:gmac-rxdv {
    rockchip,pins = <0x2b03>;
    rockchip,pull = <4>;
   };

   gmac_txclk:gmac-txclk {
    rockchip,pins = <0x2b13>;
    rockchip,pull = <4>;
   };

   gmac_crs:gmac-crs {
    rockchip,pins = <0x2b23>;
    rockchip,pull = <4>;
   };

   gmac_rxclk:gmac-rxclk {
    rockchip,pins = <0x2b33>;
    rockchip,pull = <4>;
   };

   gmac_mdio:gmac-mdio {
    rockchip,pins = <0x2b43>;
    rockchip,pull = <4>;
   };

   gmac_txen:gmac-txen {
    rockchip,pins = <0x2b53>;
    rockchip,pull = <4>;
   };

   gmac_clk:gmac-clk {
    rockchip,pins = <0x2b63>;
    rockchip,pull = <4>;
   };
   gmac_rxer:gmac-rxer {
    rockchip,pins = <0x2b73>;
    rockchip,pull = <4>;
   };

   gmac_rxd1:gmac-rxd1 {
    rockchip,pins = <0x2c03>;
    rockchip,pull = <4>;
   };

   gmac_rxd0:gmac-rxd0 {
    rockchip,pins = <0x2c13>;
    rockchip,pull = <4>;
   };

   gmac_txd1:gmac-txd1 {
    rockchip,pins = <0x2c23>;
    rockchip,pull = <4>;
   };

   gmac_txd0:gmac-txd0 {
    rockchip,pins = <0x2c33>;
    rockchip,pull = <4>;
   };
   gmac_rxd3:gmac-rxd3 {
    rockchip,pins = <0x2c44>;
    rockchip,pull = <4>;
   };

   gmac_rxd2:gmac-rxd2 {
    rockchip,pins = <0x2c54>;
    rockchip,pull = <4>;
   };

   gmac_txd2:gmac-txd2 {
    rockchip,pins = <0x2c64>;
    rockchip,pull = <4>;
   };

   gmac_txd3:gmac-txd3 {
    rockchip,pins = <0x2c74>;
    rockchip,pull = <4>;
   };

   gmac_col:gmac-col {
    rockchip,pins = <0x2d04>;
    rockchip,pull = <4>;
   };

   gmac_col_gpio:gmac-col-gpio {
    rockchip,pins = <0x2d00>;
    rockchip,pull = <4>;
   };

   gmac_mdc:gmac-mdc {
    rockchip,pins = <0x2d13>;
    rockchip,pull = <4>;
   };


  };

  gpio2_lcdc0 {
   lcdc0_lcdc:lcdc0-lcdc {
    rockchip,pins =
      <0x2b01>,
      <0x2b31>,
      <0x2b11>,
      <0x2b21>;
    rockchip,pull = <4>;
   };

   lcdc0_gpio:lcdc0-gpio {
    rockchip,pins =
      <((0x2b01) & 0xfff0)>,
      <((0x2b31) & 0xfff0)>,
      <((0x2b11) & 0xfff0)>,
      <((0x2b21) & 0xfff0)>;
    rockchip,pull = <4>;
   };

  };

  gpio2_lcdc0_d {
   lcdc0_lcdc_d: lcdc0-lcdc_d {
    rockchip,pins =
      <0x2b41>,
      <0x2b51>,
      <0x2b61>,
      <0x2b71>,
      <0x2c01>,
      <0x2c11>,
      <0x2c21>,
      <0x2c31>;
# 863 "arch/arm/boot/dts/rk312x-pinctrl.dtsi"
    rockchip,pull = <4>;
   };

   lcdc0_lcdc_gpio: lcdc0-lcdc_gpio {
    rockchip,pins =
      <((0x2b41) & 0xfff0)>,
      <((0x2b51) & 0xfff0)>,
      <((0x2b61) & 0xfff0)>,
      <((0x2b71) & 0xfff0)>,
      <((0x2c01) & 0xfff0)>,
      <((0x2c11) & 0xfff0)>,
      <((0x2c21) & 0xfff0)>,
      <((0x2c31) & 0xfff0)>;
# 884 "arch/arm/boot/dts/rk312x-pinctrl.dtsi"
    rockchip,pull = <2>;
   };

  };




 };

};
# 10 "arch/arm/boot/dts/rk312x.dtsi" 2

/ {
 compatible = "rockchip,rk312x";
 rockchip,sram = <&sram>;
 interrupt-parent = <&gic>;

 aliases {
  serial0 = &uart0;
  serial1 = &uart1;
  serial2 = &uart2;
  i2c0 = &i2c0;
  i2c1 = &i2c1;
  i2c2 = &i2c2;
  i2c3 = &i2c3;
  lcdc = &lcdc;
  spi0 = &spi0;
 };

 cpus {
  #address-cells = <1>;
  #size-cells = <0>;

  cpu@0 {
   device_type = "cpu";
   compatible = "arm,cortex-a7";
   reg = <0xf00>;
  };
  cpu@1 {
   device_type = "cpu";
   compatible = "arm,cortex-a7";
   reg = <0xf01>;
  };
  cpu@2 {
   device_type = "cpu";
   compatible = "arm,cortex-a7";
   reg = <0xf02>;
  };
  cpu@3 {
   device_type = "cpu";
   compatible = "arm,cortex-a7";
   reg = <0xf03>;
  };
 };

 gic: interrupt-controller@10139000 {
  compatible = "arm,cortex-a15-gic";
  interrupt-controller;
  #interrupt-cells = <3>;
  #address-cells = <0>;
  reg = <0x10139000 0x1000>,
        <0x1013a000 0x1000>;
 };

 arm-pmu {
  compatible = "arm,cortex-a7-pmu";
  interrupts = <0 76 4>,
        <0 77 4>,
        <0 78 4>,
        <0 79 4>;
 };

 cpu_axi_bus: cpu_axi_bus {
  compatible = "rockchip,cpu_axi_bus";
  #address-cells = <1>;
  #size-cells = <1>;
  ranges;

  qos {
   #address-cells = <1>;
   #size-cells = <1>;
   ranges;

   crypto {
    reg = <0x10128080 0x20>;
   };
   core {
    reg = <0x1012a000 0x20>;
   };
   peri {
    reg = <0x1012c000 0x20>;
   };
   gpu {
    reg = <0x1012d000 0x20>;
   };
   vpu {
    reg = <0x1012e000 0x20>;
   };
   rga {
    reg = <0x1012f000 0x20>;
   };
   ebc {
    reg = <0x1012f080 0x20>;
   };
   iep {
    reg = <0x1012f100 0x20>;
   };
   lcdc {
    reg = <0x1012f180 0x20>;
    rockchip,priority = <3 3>;
   };
   vip {
    reg = <0x1012f200 0x20>;
    rockchip,priority = <3 3>;
   };
  };

  msch {
   #address-cells = <1>;
   #size-cells = <1>;
   ranges;

   msch@10128000 {
    reg = <0x10128000 0x20>;
    rockchip,read-latency = <0x3f>;
   };
  };
 };

 sram: sram@10080400 {
  compatible = "mmio-sram";
  reg = <0x10080400 0x1C00>;
  map-exec;
  map-cacheable;
 };

 timer {
  compatible = "arm,armv7-timer";
  interrupts = <1 13 ((((1 << (4)) - 1) << 8) | 4)>,
        <1 14 ((((1 << (4)) - 1) << 8) | 4)>;
  clock-frequency = <24000000>;
 };

 timer@20044000 {
  compatible = "rockchip,timer";
  reg = <0x20044000 0x20>;
  interrupts = <0 28 4>;
  rockchip,broadcast = <1>;
 };

 watchdog: wdt@2004c000 {
  compatible = "rockchip,watch dog";
  reg = <0x2004c000 0x100>;

  clock-names = "pclk_wdt";
  interrupts = <0 34 4>;
  rockchip,irq = <1>;
  rockchip,timeout = <60>;
  rockchip,atboot = <1>;
  rockchip,debug = <0>;
  status = "disabled";
 };

 amba {
  #address-cells = <1>;
  #size-cells = <1>;
  compatible = "arm,amba-bus";
  interrupt-parent = <&gic>;
  ranges;

  pdma: pdma@20078000 {
   compatible = "arm,pl330", "arm,primecell";
   reg = <0x20078000 0x4000>;
   interrupts = <0 0 4>,
         <0 1 4>;
   #dma-cells = <1>;
  };
 };

 reset: reset@20000110 {
  compatible = "rockchip,reset";
  reg = <0x20000110 0x24>;
  rockchip,reset-flag = <(1 << (0))>;
  #reset-cells = <1>;
 };

 nandc: nandc@10500000 {
  compatible = "rockchip,rk-nandc";
  reg = <0x10500000 0x4000>;
  interrupts = <0 18 4>;


  nandc_id = <0>;
  clocks = <&clk_nandc>, <&clk_gates5 9>, <&clk_gates10 15>;
  clock-names = "clk_nandc", "g_clk_nandc", "hclk_nandc";
 };

 nandc0reg: nandc0@10500000 {
  compatible = "rockchip,rk-nandc";
  reg = <0x10500000 0x4000>;
 };
 uart0: serial@20060000 {
  compatible = "rockchip,serial";
  reg = <0x20060000 0x100>;
  interrupts = <0 20 4>;
  clock-frequency = <24000000>;
  clocks = <&clk_uart0>, <&clk_gates8 0>;
  clock-names = "sclk_uart", "pclk_uart";
  reg-shift = <2>;
  reg-io-width = <4>;
  dmas = <&pdma 2>, <&pdma 3>;
  #dma-cells = <2>;
  pinctrl-names = "default";
  pinctrl-0 = <&uart0_xfer &uart0_cts &uart0_rts>;
  status = "disabled";
 };

 uart1: serial@20064000 {
  compatible = "rockchip,serial";
  reg = <0x20064000 0x100>;
  interrupts = <0 21 4>;
  clock-frequency = <24000000>;
  clocks = <&clk_uart1>, <&clk_gates8 1>;
  clock-names = "sclk_uart", "pclk_uart";
  reg-shift = <2>;
  reg-io-width = <4>;
  dmas = <&pdma 4>, <&pdma 5>;
  #dma-cells = <2>;
  pinctrl-names = "default";
  pinctrl-0 = <&uart1_xfer &uart1_cts &uart1_rts>;
  status = "disabled";
 };

 uart2: serial@20068000 {
  compatible = "rockchip,serial";
  reg = <0x20068000 0x100>;
  interrupts = <0 22 4>;
  clock-frequency = <24000000>;
  clocks = <&clk_uart2>, <&clk_gates8 2>;
  clock-names = "sclk_uart", "pclk_uart";
  reg-shift = <2>;
  reg-io-width = <4>;
  dmas = <&pdma 6>, <&pdma 7>;
  #dma-cells = <2>;
  pinctrl-names = "default";
  pinctrl-0 = <&uart2_xfer>;
  status = "disabled";
 };

 gmac: eth@2008c000 {
  compatible = "rockchip,rk312x-gmac";
  reg = <0x2008c000 0x4000>;
  interrupts = <0 56 4>;
  interrupt-names = "macirq";
  clocks = <&clk_mac_ref>, <&clk_gates2 6>,
   <&clk_gates2 7>, <&clk_gates2 4>,
   <&clk_gates2 5>, <&clk_gates10 10>,
   <&clk_gates10 11>;
  clock-names = "clk_mac", "mac_clk_rx",
   "mac_clk_tx", "clk_mac_ref",
   "clk_mac_refout", "aclk_mac",
   "pclk_mac";
  phy-mode = "rgmii";
  pinctrl-names = "default";
  pinctrl-0 = <&gmac_rxdv &gmac_txclk &gmac_crs &gmac_rxclk &gmac_mdio &gmac_txen &gmac_clk &gmac_rxer &gmac_rxd1 &gmac_rxd0 &gmac_txd1 &gmac_txd0 &gmac_rxd3 &gmac_rxd2 &gmac_txd2 &gmac_txd3 &gmac_col_gpio &gmac_mdc>;
 };

 fiq-debugger {
  compatible = "rockchip,fiq-debugger";
  rockchip,serial-id = <2>;
  rockchip,signal-irq = <106>;
  rockchip,wake-irq = <0>;
  status = "disabled";
 };

 rockchip_clocks_init: clocks-init{
  compatible = "rockchip,clocks-init";
  rockchip,clocks-init-parent =
   <&clk_core &clk_apll>, <&aclk_cpu &clk_gpll_div2>,
   <&aclk_peri &clk_gpll_div2>, <&clk_uart0_pll &clk_gpll>,
   <&clk_uart2_pll &clk_gpll>, <&clk_i2s_2ch_pll &clk_gpll>,
   <&clk_i2s_8ch_pll &clk_gpll>, <&clk_spdif_pll &clk_gpll>,
   <&clk_vepu &clk_gpll_div2>, <&clk_vdpu &clk_gpll_div2>,
   <&clk_hevc_core &clk_gpll>, <&aclk_vio0_pre &clk_gpll_div2>,
   <&aclk_vio1_pre &clk_gpll_div2>, <&hclk_vio_pre &clk_gpll_div2>,
   <&sclk_lcdc0 &clk_cpll>, <&clk_gpu &clk_gpll_div2>,
   <&clk_cif_pll &clk_gpll_div2>, <&dclk_ebc &clk_gpll_div2>,
   <&clk_emmc &clk_gpll_div2>, <&clk_sdio &clk_gpll_div2>,
   <&clk_sfc &clk_gpll_div2>, <&clk_sdmmc0 &clk_gpll_div2>,
   <&clk_tsp &clk_gpll_div2>, <&clk_nandc &clk_gpll_div2>,
   <&clk_mac_pll &clk_cpll>;
  rockchip,clocks-init-rate =
   <&clk_core 600000000>, <&clk_gpll 594000000>,
    <&clk_cpll 400000000>, <&aclk_cpu 300000000>,
   <&hclk_cpu_pre 150000000>, <&pclk_cpu_pre 75000000>,
   <&aclk_peri 300000000>, <&hclk_peri_pre 150000000>,
   <&pclk_peri_pre 75000000>, <&clk_gpu 300000000>,
   <&aclk_vio0_pre 300000000>, <&hclk_vio_pre 150000000>,
   <&aclk_vio1_pre 300000000>, <&clk_vepu 300000000>,
   <&clk_vdpu 300000000>, <&clk_hevc_core 200000000>,
   <&clk_mac_ref 125000000>;


 };
 gpu {
  compatible = "arm,mali400";
  reg = <0x10091000 0x200>,
        <0x10090000 0x100>,
        <0x10093000 0x100>,
        <0x10098000 0x1100>,
        <0x10094000 0x100>,
        <0x1009A000 0x1100>,
        <0x10095000 0x100>;

  reg-names = "Mali_L2",
       "Mali_GP",
       "Mali_GP_MMU",
       "Mali_PP0",
       "Mali_PP0_MMU",
       "Mali_PP1",
       "Mali_PP1_MMU";

      interrupts = <0 3 4>,
            <0 4 4>,
        <0 5 4>,
        <0 4 4>,
        <0 5 4>,
        <0 4 4>;

  interrupt-names = "Mali_GP_IRQ",
                 "Mali_GP_MMU_IRQ",
             "Mali_PP0_IRQ",
             "Mali_PP0_MMU_IRQ",
             "Mali_PP1_IRQ",
             "Mali_PP1_MMU_IRQ";
   };

 clocks-enable {
  compatible = "rockchip,clocks-enable";
  clocks =

    <&clk_gates0 6>,<&clk_gates0 0>,
    <&clk_gates0 7>,


    <&clk_gates0 1>, <&clk_gates0 3>,
    <&clk_gates0 4>, <&clk_gates0 5>,
    <&clk_gates0 12>,


    <&clk_gates10 3>, <&clk_gates10 4>,
    <&clk_gates10 5>, <&clk_gates10 6>,
    <&clk_gates10 7>, <&clk_gates10 8>,


    <&clk_gates2 0>, <&hclk_peri_pre>,
    <&pclk_peri_pre>, <&clk_gates2 1>,


    <&clk_gates4 12>,
    <&clk_gates4 10>,



    <&clk_gates3 5>,


    <&clk_gates5 4>,
    <&clk_gates5 7>,





    <&clk_gates4 3>,
    <&clk_gates5 1>,
    <&clk_gates9 15>,
    <&clk_gates9 2>,
    <&clk_gates9 3>,
    <&clk_gates4 2>,


    <&clk_gates4 0>,

    <&clk_gates9 14>,


    <&clk_gates4 1>,
# 400 "arch/arm/boot/dts/rk312x.dtsi"
    <&clk_gates1 12>,
    <&clk_gates1 13>,
    <&clk_gates8 2>,







    <&clk_gates1 0>;
 };

 i2c0: i2c@20072000 {
  compatible = "rockchip,rk30-i2c";
  reg = <0x20072000 0x1000>;
  interrupts = <0 24 4>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default", "gpio";
  pinctrl-0 = <&i2c0_sda &i2c0_scl>;
  pinctrl-1 = <&i2c0_gpio>;
  gpios = <&gpio0 1 1>, <&gpio0 0 1>;
  clocks = <&clk_gates8 4>;
  rockchip,check-idle = <1>;
  status = "disabled";
 };

 i2c1: i2c@20056000 {
  compatible = "rockchip,rk30-i2c";
  reg = <0x20056000 0x1000>;
  interrupts = <0 25 4>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default", "gpio";
  pinctrl-0 = <&i2c1_sda &i2c1_scl>;
  pinctrl-1 = <&i2c1_gpio>;
  gpios = <&gpio0 3 1>, <&gpio0 2 1>;
  clocks = <&clk_gates8 5>;
  rockchip,check-idle = <1>;
  status = "disabled";
 };

 i2c2: i2c@2005a000 {
  compatible = "rockchip,rk30-i2c";
  reg = <0x2005a000 0x1000>;
  interrupts = <0 26 4>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default", "gpio";
  pinctrl-0 = <&i2c2_sda &i2c2_scl>;
  pinctrl-1 = <&i2c2_gpio>;
  gpios = <&gpio2 20 1>, <&gpio2 21 1>;
  clocks = <&clk_gates8 6>;
  rockchip,check-idle = <1>;
  status = "disabled";
 };

 i2c3: i2c@2005e000 {
  compatible = "rockchip,rk30-i2c";
  reg = <0x2005e000 0x1000>;
  interrupts = <0 27 4>;
  #address-cells = <1>;
  #size-cells = <0>;
                pinctrl-names = "default", "gpio";
  pinctrl-0 = <&i2c3_sda &i2c3_scl>;
  pinctrl-1 = <&i2c3_gpio>;
  gpios = <&gpio0 7 1>, <&gpio0 6 1>;
  clocks = <&clk_gates8 7>;
  rockchip,check-idle = <1>;
  status = "disabled";
 };

 i2s0: i2s0@10220000 {
  compatible = "rockchip-i2s";
  reg = <0x10220000 0x1000>;
  i2s-id = <0>;
  clocks = <&clk_i2s_2ch>, <&clk_i2s_2ch_out>, <&clk_gates7 2>;
  clock-names = "i2s_clk", "i2s_mclk", "i2s_hclk";
  interrupts = <0 19 4>;
  dmas = <&pdma 0>, <&pdma 1>;

  dma-names = "tx", "rx";



  status = "disabled";
 };

 i2s1: i2s1@10200000 {
  compatible = "rockchip-i2s";
  reg = <0x10200000 0x1000>;
  i2s-id = <1>;
  clocks = <&clk_i2s_8ch>, <&clk_gates7 4>;
  clock-names = "i2s_clk", "i2s_hclk";
  interrupts = <0 68 4>;
  dmas = <&pdma 14>, <&pdma 15>;

  dma-names = "tx", "rx";
 };

 spdif: spdif@10204000 {
  compatible = "rockchip-spdif";
  reg = <0x10204000 0x1000>;
  clocks = <&clk_spdif>, <&clk_gates10 9>;
  clock-names = "spdif_mclk", "spdif_hclk";
  interrupts = <0 55 4>;
  dmas = <&pdma 13>;

  dma-names = "tx";
  pinctrl-names = "default";
  pinctrl-0 = <&spdif_tx>;
 };

 dsihost0: mipi@10110000{
  compatible = "rockchip,rk312x-dsi";
  rockchip,prop = <0>;
  reg = <0x10110000 0x4000>, <0x20038000 0x4000>;
  reg-names = "mipi_dsi_host" ,"mipi_dsi_phy";
  interrupts = <0 19 4>;
  clocks = <&clk_gates2 15>, <&clk_gates5 0>, <&clk_gates9 6>, <&clk_gates9 5>, <&pd_mipidsi>;
  clock-names = "clk_mipi_24m", "pclk_mipi_dsi", "pclk_mipi_dsi_host", "hclk_vio_h2p", "pd_mipi_dsi";
  status = "okay";
 };

 emmc: rksdmmc@1021c000 {
  compatible = "rockchip,rk_mmc", "rockchip,rk312x-sdmmc";
  reg = <0x1021c000 0x4000>;
  interrupts = <0 16 4>;
  #address-cells = <1>;
  #size-cells = <0>;


  clocks = <&clk_emmc>, <&clk_gates7 0>;
  clock-names = "clk_mmc", "hclk_mmc";
  dmas = <&pdma 12>;
  dma-names = "dw_mci";
  num-slots = <1>;
  fifo-depth = <0x100>;
  bus-width = <8>;
         cru_regsbase = <0x124>;
  cru_reset_offset = <3>;
        };


        sdmmc: rksdmmc@10214000 {
  compatible = "rockchip,rk_mmc", "rockchip,rk312x-sdmmc";
  reg = <0x10214000 0x4000>;
  interrupts = <0 14 4>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default", "idle", "udbg";
  pinctrl-0 = <&sdmmc0_clk &sdmmc0_cmd &sdmmc0_dectn &sdmmc0_bus4>;
  pinctrl-1 = <&sdmmc0_gpio>;
  pinctrl-2 = <&uart2_xfer &sdmmc0_dectn>;
  clocks = <&clk_sdmmc0>, <&clk_gates5 10>;
  clock-names = "clk_mmc", "hclk_mmc";
  dmas = <&pdma 10>;
  dma-names = "dw_mci";
  num-slots = <1>;
  fifo-depth = <0x100>;
  bus-width = <4>;
         cru_regsbase = <0x124>;
  cru_reset_offset = <1>;
 };

 sdio: rksdmmc@10218000 {
  compatible = "rockchip,rk_mmc", "rockchip,rk312x-sdmmc";
  reg = <0x10218000 0x4000>;
  interrupts = <0 15 4>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default","idle";
  pinctrl-0 = <&sdio0_pwren &sdio0_cmd &sdio0_clk &sdio0_bus4>;
  pinctrl-1 = <&sdio0_gpio>;
  clocks = <&clk_sdio>, <&clk_gates5 11>;
  clock-names = "clk_mmc", "hclk_mmc";
  dmas = <&pdma 11>;
  dma-names = "dw_mci";
  num-slots = <1>;
  fifo-depth = <0x100>;
  bus-width = <4>;
         cru_regsbase = <0x124>;
  cru_reset_offset = <2>;
 };

 spi0: spi@20074000 {
  compatible = "rockchip,rockchip-spi";
  reg = <0x20074000 0x1000>;
  interrupts = <0 23 4>;
  #address-cells = <1>;
  #size-cells = <0>;
  pinctrl-names = "default";
  pinctrl-0 = <&spi0_txd_mux0 &spi0_rxd_mux0 &spi0_clk_mux0 &spi0_cs0_mux0 &spi0_cs1_mux0>;


  rockchip,spi-src-clk = <0>;
  num-cs = <2>;
  clocks =<&clk_spi0>, <&clk_gates7 12>;
  clock-names = "spi","pclk_spi0";
  dmas = <&pdma 8>, <&pdma 9>;
  #dma-cells = <2>;
  dma-names = "tx", "rx";
  status = "disabled";
 };

 adc: adc@2006c000 {
  compatible = "rockchip,saradc";
  reg = <0x2006c000 0x100>;
  interrupts = <0 17 4>;
  #io-channel-cells = <1>;
  io-channel-ranges;
  rockchip,adc-vref = <1800>;
  clock-frequency = <1000000>;
  clocks = <&clk_saradc>, <&clk_gates7 14>;
  clock-names = "saradc", "pclk_saradc";
  status = "disabled";
 };

 pwm0: pwm@20050000 {
  compatible = "rockchip,rk-pwm";
  reg = <0x20050000 0x10>;
  #pwm-cells = <2>;
  pinctrl-names = "default";
  pinctrl-0 = <&pwm0_pin>;
  clocks = <&clk_gates7 10>;
  clock-names = "pclk_pwm";
  status = "disabled";
 };

        pwm1: pwm@20050010 {
                compatible = "rockchip,rk-pwm";
                reg = <0x20050010 0x10>;
                #pwm-cells = <2>;
                pinctrl-names = "default";
                pinctrl-0 = <&pwm1_pin>;
                clocks = <&clk_gates7 10>;
                clock-names = "pclk_pwm";
                status = "disabled";
        };

        pwm2: pwm@20050020 {
                compatible = "rockchip,rk-pwm";
                reg = <0x20050020 0x10>;
                #pwm-cells = <2>;
                pinctrl-names = "default";
                pinctrl-0 = <&pwm2_pin>;
                clocks = <&clk_gates7 10>;
                clock-names = "pclk_pwm";
                status = "disabled";
        };

        pwm3: pwm@20050030 {
                compatible = "rockchip,rk-pwm";
                reg = <0x20050030 0x10>;
                #pwm-cells = <2>;
                pinctrl-names = "default";
                pinctrl-0 = <&pwm3_pin>;
                clocks = <&clk_gates7 10>;
                clock-names = "pclk_pwm";
                status = "disabled";
        };

 remotectl: pwm@20050030 {
  compatible = "rockchip,remotectl-pwm";
  reg = <0x20050030 0x10>;
  #pwm-cells = <2>;
  pinctrl-names = "default";
  pinctrl-0 = <&pwm3_pin>;
  clocks = <&clk_gates7 10>;
  clock-names = "pclk_pwm";
  remote_pwm_id = <3>;
  interrupts = <0 30 4>;
  status = "okay";
 };
 dwc_control_usb: dwc-control-usb@20008000 {
  compatible = "rockchip,rk3126-dwc-control-usb";
  reg = <0x20008000 0x4>;
  interrupts = <0 35 4>;
  interrupt-names = "otg_bvalid";
  clocks = <&clk_gates9 13>;
  clock-names = "hclk_usb_peri";
  rockchip,remote_wakeup;
  rockchip,usb_irq_wakeup;
  resets = <&reset 105>;
  reset-names = "usbphy_por";
  usb_bc{
   compatible = "inno,phy";
   regbase = &dwc_control_usb;
   rk_usb,bvalid = <0x14c 5 1>;
   rk_usb,iddig = <0x14c 8 1>;
   rk_usb,vdmsrcen = <0x184 12 1>;
   rk_usb,vdpsrcen = <0x184 11 1>;
   rk_usb,rdmpden = <0x184 10 1>;
   rk_usb,idpsrcen = <0x184 9 1>;
   rk_usb,idmsinken = <0x184 8 1>;
   rk_usb,idpsinken = <0x184 7 1>;
   rk_usb,dpattach = <0x2c0 7 1>;
   rk_usb,cpdet = <0x2c0 6 1>;
   rk_usb,dcpattach = <0x2c0 5 1>;
  };
 };

 usb0: usb@10180000 {
  compatible = "rockchip,rk3126_usb20_otg";
  reg = <0x10180000 0x40000>;
  interrupts = <0 10 4>;
  clocks = <&clk_gates1 5>, <&clk_gates5 13>;
  clock-names = "clk_usbphy0", "hclk_usb0";
  resets = <&reset 69>, <&reset 103>,
    <&reset 71>;
  reset-names = "otg_ahb", "otg_phy", "otg_controller";

  rockchip,usb-mode = <0>;
 };

 ehci: usb@101c0000 {
  compatible = "rockchip,rk3126_ehci";
  reg = <0x101c0000 0x20000>;
  interrupts = <0 11 4>;
  clocks = <&clk_gates1 6>, <&clk_gates7 3>;
  clock-names = "clk_usbphy1", "hclk_host0";
  resets = <&reset 72>, <&reset 104>,
    <&reset 74>;
  reset-names = "host_ahb", "host_phy", "host_controller";
 };

 ohci: usb@101e0000 {
  compatible = "rockchip,rk3126_ohci";
  reg = <0x101e0000 0x20000>;
  interrupts = <0 32 4>;
 };

 fb: fb{
  compatible = "rockchip,rk-fb";
  rockchip,disp-mode = <1>;
 };

 rk_screen: rk_screen{
  compatible = "rockchip,screen";
 };

 lvds: lvds@20038000 {
  compatible = "rockchip,rk31xx-lvds";
  reg = <0x20038000 0x4000>, <0x101100b0 0x01>;
  reg-names = "mipi_lvds_phy", "mipi_lvds_ctl";
  clocks = <&clk_gates5 0>, <&clk_gates9 6>, <&clk_gates9 5>;
  clock-names = "pclk_lvds", "pclk_lvds_ctl", "hclk_vio_h2p";
  status = "disabled";
 };

 lcdc: lcdc@1010e000 {
  compatible = "rockchip,rk312x-lcdc";
  rockchip,prop = <1>;
  reg = <0x1010e000 0x1000>;
  interrupts = <0 9 4>;
  clocks = <&clk_gates6 0>, <&dclk_lcdc0>, <&clk_gates6 1>, <&sclk_lcdc0>, <&pd_vop>, <&clk_cpll>;
  clock-names = "aclk_lcdc", "dclk_lcdc", "hclk_lcdc", "sclk_lcdc", "pd_lcdc", "sclk_pll";
  rockchip,iommu-enabled = <1>;
  status = "disabled";
 };

 hdmi: hdmi@20034000 {
  compatible = "rockchip,rk312x-hdmi";
  reg = <0x20034000 0x4000>;
  interrupts = <0 45 4>;
  rockchip,hdmi_lcdc_source = <0>;
  pinctrl-names = "default", "gpio";
  pinctrl-0 = <&hdmi_cec &hdmi_sda &hdmi_scl &hdmi_hpd>;
  pinctrl-1 = <&hdmi_gpio>;
  clocks = <&clk_gates3 8>, <&pd_hdmi>;
  clock-names = "pclk_hdmi", "pd_hdmi";
  rockchip,hdcp_enable = <0>;
  rockchip,cec_enable = <0>;
  status = "disabled";
 };

 tve: tve{
  compatible = "rockchip,rk312x-tve";
  reg = <0x1010e200 0x100>;
  status = "disabled";
 };

 vpu: vpu_service {
  compatible = "rockchip,vpu_sub";
  iommu_enabled = <1>;
  reg = <0x10106000 0x800>;
  interrupts = <0 6 4>,
        <0 7 4>;
  interrupt-names = "irq_enc", "irq_dec";
  dev_mode = <0>;
  name = "vpu_service";
 };

 hevc: hevc_service {
  compatible = "rockchip,hevc_sub";
  iommu_enabled = <1>;
  reg = <0x10104000 0x400>;
  interrupts = <0 66 4>;
  interrupt-names = "irq_dec";
  dev_mode = <1>;
  name = "hevc_service";
 };

 vpu_combo: vpu_combo@ff9a0000 {
  compatible = "rockchip,vpu_combo";
  subcnt = <2>;
  rockchip,sub = <&vpu>, <&hevc>;
  clocks = <&clk_vdpu>, <&hclk_vdpu>, <&clk_hevc_core>;
  clock-names = "aclk_vcodec", "hclk_vcodec", "clk_core";
  mode_bit = <15>;
  mode_ctrl = <0x144>;
  name = "vpu_combo";
  status = "okay";
 };

 iep: iep@10108000 {
  compatible = "rockchip,iep";
  iommu_enabled = <1>;
  reg = <0x10108000 0x800>;
  interrupts = <0 48 4>;
  clocks = <&clk_gates9 8>, <&clk_gates9 7>;
  clock-names = "aclk_iep", "hclk_iep";
  status = "okay";
 };

 rga: rga@1010c000 {
  compatible = "rockchip,rk312x-rga";
  reg = <0x1010c000 0x1000>;
  interrupts = <0 44 4>;
  clocks = <&clk_gates6 10>, <&clk_gates6 11>;
  clock-names = "hclk_rga", "aclk_rga";
  status = "okay";
 };

  vop_mmu {
  dbgname = "vop";
  compatible = "rockchip,vop_mmu";
  reg = <0x1010e300 0x100>;
  interrupts = <0 9 4>;
  interrupt-names = "vop_mmu";
   };

   hevc_mmu {
  dbgname = "hevc";
  compatible = "rockchip,hevc_mmu";
  reg = <0x10104440 0x40>,
        <0x10104480 0x40>;
  interrupts = <0 65 4>;
  interrupt-names = "hevc_mmu";
   };

   vpu_mmu {
  dbgname = "vpu";
  compatible = "rockchip,vpu_mmu";
  reg = <0x10106800 0x100>;
  interrupts = <0 67 4>;
  interrupt-names = "vpu_mmu";
   };

   iep_mmu {
  dbgname = "iep";
  compatible = "rockchip,iep_mmu";
  reg = <0x10108800 0x100>;
  interrupts = <0 48 4>;
  interrupt-names = "iep_mmu";
   };

   dvfs {
  vd_arm: vd_arm {
   regulator_name = "vdd_arm";
   pd_core {
    clk_core_dvfs_table: clk_core {
     operating-points = <

      312000 1100000
      504000 1100000
      816000 1100000
      1008000 1100000
      >;
     temp-limit-enable = <0>;
     target-temp = <80>;
     temp-channel = <1>;
     normal-temp-limit = <

      3 96000
      6 144000
      9 192000
      15 384000
      >;
     performance-temp-limit = <

      110 816000
      >;
     status = "okay";
     regu-mode-table = <

      1008000 4
      0 3
     >;
     regu-mode-en = <0>;
     lkg_adjust_volt_en = <1>;
     channel = <0>;
     def_table_lkg = <35>;
     min_adjust_freq = <1200000>;
     lkg_adjust_volt_table = <

      60 25000
      >;
    };
   };
  };

  vd_logic: vd_logic {
   regulator_name = "vdd_logic";
   pd_ddr {
    clk_ddr_dvfs_table: clk_ddr {
     operating-points = <

      200000 1200000
      300000 1200000
      400000 1200000
      >;
     status = "disabled";
    };
   };

   pd_gpu {
    clk_gpu_dvfs_table: clk_gpu {
     operating-points = <

      200000 1200000
      300000 1200000
      400000 1200000
      >;
     status = "okay";
     regu-mode-table = <

      200000 4
      0 3
     >;
     regu-mode-en = <0>;
    };
   };
  };
 };
 ion {
  compatible = "rockchip,ion";
  #address-cells = <1>;
  #size-cells = <0>;

  ion_cma: rockchip,ion-heap@4 {
   compatible = "rockchip,ion-heap";
   rockchip,ion_heap = <4>;
   reg = <0x00000000 0x800000>;
  };
  rockchip,ion-heap@0 {
   compatible = "rockchip,ion-heap";
   rockchip,ion_heap = <0>;
  };
 };
 cif: cif@1010a000 {
      compatible = "rockchip,cif";
      reg = <0x1010a000 0x2000>;
      interrupts = <0 8 4>;
      clocks = <&pd_vip>,<&clk_gates6 5>,<&clk_gates6 4>,<&clk_cif0_in>,<&clk_cif_out>;
      clock-names = "pd_cif0", "aclk_cif0","hclk_cif0","cif0_in","cif0_out";
      status = "okay";
      };

 codec_hdmi_spdif: codec-hdmi-spdif {
  compatible = "hdmi-spdif";
 };

 rockchip-hdmi-spdif {
  compatible = "rockchip-hdmi-spdif";
  dais {
   dai0 {
    audio-codec = <&codec_hdmi_spdif>;
    audio-controller = <&spdif>;
   };
  };
 };
 codec: codec@20030000 {
  compatible = "rk312x-codec";
  reg = <0x20030000 0x4000>;


  boot_depop = <1>;
  pa_enable_time = <1000>;
  clocks = <&clk_gates5 14>;
  clock-names = "g_pclk_acodec";
 };
 rockchip_audio: audio-rk312x {
  compatible = "audio-rk312x";
  dais {
   dai0 {
    audio-codec = <&codec>;
    audio-controller = <&i2s1>;
    format = "i2s";





   };
   dai1 {
    audio-codec = <&codec>;
    audio-controller = <&i2s1>;
    format = "i2s";





   };
  };
 };
};
# 1 "arch/arm/boot/dts/rk3128.dtsi" 2
# 4 "arch/arm/boot/dts/rk3128-fireprime.dts" 2
# 1 "arch/arm/boot/dts/rk3128-cif-sensor.dtsi" 1
# 1 "arch/arm/boot/dts/../../mach-rockchip/rk_camera_sensor_info.h" 1
# 2 "arch/arm/boot/dts/rk3128-cif-sensor.dtsi" 2
/{
 rk3128_cif_sensor: rk3128_cif_sensor{
   compatible = "rockchip,sensor";
   status = "disabled";
   CONFIG_SENSOR_POWER_IOCTL_USR = <1>;
   CONFIG_SENSOR_RESET_IOCTL_USR = <0>;
   CONFIG_SENSOR_POWERDOWN_IOCTL_USR = <0>;
   CONFIG_SENSOR_FLASH_IOCTL_USR = <0>;
   CONFIG_SENSOR_AF_IOCTL_USR = <0>;

                   s5k4ec{
                           status = "okay";
                           is_front = <0>;
                           rockchip,power_pmu_name1 = "rk818_ldo4";
                           rockchip,power_pmu_voltage1 = <2800000>;
                           rockchip,power_pmu_name2 = "rk818_ldo8";
                           rockchip,power_pmu_voltage2 = <1800000>;
                           rockchip,powerdown = <&gpio3 31 0>;
                           pwdn_active = <0>;
                           tchip,rst = <&gpio3 11 1>;
                           #rockchip,reset = <>;
                           #rst_active = <>;
                           flash_attach = <1>;
                           flash_active = <1>;
                           #rockchip,af = <>;
                           mir = <0>;
                           resolution = <0x500000>;
                           powerup_sequence = <((0x04<<(2*4))| (0x06<<(1*4))| (0x07<<(0*4)))>;
                           orientation = <0>;
                           i2c_add = <0x5a>;
                           i2c_rata = <20000>;
                           i2c_chl = <0>;
                           cif_chl = <0>;
                           mclk_rate = <24>;
                   };

  ov2659{
   is_front = <1>;
   rockchip,powerdown = <&gpio3 31 0>;
   pwdn_active = <0x01>;
   #rockchip,power = <>;
   pwr_active = <0x01>;
   #rockchip,reset = <>;
   #rst_active = <>;
   #rockchip,flash = <>;
   #rockchip,af = <>;
   mir = <0>;
   flash_attach = <0>;
   resolution = <0x200000>;
   powerup_sequence = <((0x04<<(0*4))| (0x05<<(1*4))| (0x06<<(2*4))| (0x07<<(3*4)))>;
   orientation = <0>;
   i2c_add = <0x60>;
   i2c_rata = <100000>;
   i2c_chl = <0>;
   cif_chl = <0>;
   mclk_rate = <24>;
  };
  gc0329{
   is_front = <1>;
   rockchip,powerdown = <&gpio3 31 0>;
   pwdn_active = <0x01>;
   #rockchip,power = <>;
   pwr_active = <0x01>;
   #rockchip,reset = <>;
   #rst_active = <>;
   #rockchip,flash = <>;
   #rockchip,af = <>;
   mir = <0>;
   flash_attach = <0>;
   resolution = <0x30000>;
   powerup_sequence = <((0x04<<(0*4))| (0x05<<(1*4))| (0x06<<(2*4))| (0x07<<(3*4)))>;
   orientation = <0>;
   i2c_add = <0x62>;
   i2c_rata = <100000>;
   i2c_chl = <0>;
   cif_chl = <0>;
   mclk_rate = <24>;
  };

     gc2035{
            is_front = <0>;
            rockchip,power = <&gpio2 10 0>;

            pwdn_active = <0x01>;
            pwr_active = <0x01>;
            mir = <0>;
            flash_attach = <0>;
            resolution = <0x200000>;
            powerup_sequence = <((0x04<<(0*4))| (0x05<<(1*4))| (0x06<<(2*4))| (0x07<<(3*4)))>;
            orientation = <180>;
            i2c_add = <0x78>;
            i2c_rata = <100000>;
            i2c_chl = <2>;
            cif_chl = <0>;
            mclk_rate = <24>;
        };
     gc0308{
   is_front = <1>;
   rockchip,power = <&gpio2 10 0>;
   rockchip,powerdown = <&gpio3 31 0>;
   pwdn_active = <0x01>;
   pwr_active = <0x01>;
   mir = <0>;
   flash_attach = <0>;
   resolution = <0x30000>;
   powerup_sequence = <((0x04<<(0*4))| (0x05<<(1*4))| (0x06<<(2*4))| (0x07<<(3*4)))>;
   orientation = <180>;
   i2c_add = <0x42>;
   i2c_rata = <100000>;
   i2c_chl = <2>;
   cif_chl = <0>;
   mclk_rate = <24>;
  };

 };
};
# 5 "arch/arm/boot/dts/rk3128-fireprime.dts" 2
# 1 "arch/arm/boot/dts/rk312x-sdk.dtsi" 1

/ {
 fiq-debugger {
  status = "okay";
 };

 chosen {
  bootargs = "vmalloc=496M rockchip_jtag";
 };

 pwm_regulator1:pwm-regulator1 {
  compatible = "rockchip_pwm_regulator";
  pwms = <&pwm1 0 25000>;
  rockchip,pwm_id= <1>;
  rockchip,pwm_voltage_map= <950000 975000 1000000 1025000 1050000 1075000 1100000 1125000 1150000 1175000 1200000 1225000 1250000 1275000 1300000 1325000 1350000 1375000 1400000 1425000 1450000>;
  rockchip,pwm_voltage= <1250000>;
  rockchip,pwm_min_voltage= <950000>;
  rockchip,pwm_max_voltage= <1450000>;
  rockchip,pwm_suspend_voltage= <1250000>;
  rockchip,pwm_coefficient= <550>;
  status = "disabled";
  regulators {
   #address-cells = <1>;
   #size-cells = <0>;
   pwm_reg0: regulator@0 {
    regulator-compatible = "pwm_dcdc1";
    regulator-name= "vdd_arm";
    regulator-min-microvolt = <950000>;
    regulator-max-microvolt = <1450000>;
    regulator-always-on;
    regulator-boot-on;
   };
  };
 };

 pwm_regulator2:pwm-regulator2 {
  compatible = "rockchip_pwm_regulator";
  pwms = <&pwm2 0 25000>;
  rockchip,pwm_id= <2>;
  rockchip,pwm_voltage_map= <950000 975000 1000000 1025000 1050000 1075000 1100000 1125000 1150000 1175000 1200000 1225000 1250000 1275000 1300000 1325000 1350000 1375000 1400000 1425000 1450000>;
  rockchip,pwm_voltage= <1200000>;
  rockchip,pwm_min_voltage= <950000>;
  rockchip,pwm_max_voltage= <1450000>;
  rockchip,pwm_suspend_voltage= <1250000>;
  rockchip,pwm_coefficient= <550>;
  status = "disabled";
  regulators {
   #address-cells = <1>;
   #size-cells = <0>;
   pwm_reg1: regulator@1 {
    regulator-compatible = "pwm_dcdc2";
    regulator-name= "vdd_logic";
    regulator-min-microvolt = <950000>;
    regulator-max-microvolt = <1450000>;
    regulator-always-on;
    regulator-boot-on;
   };
  };
 };

};

&nandc {
 status = "okay";
};

&nandc0reg {
 status = "disabled";
};

&emmc {
 clock-frequency = <50000000>;
 clock-freq-min-max = <400000 50000000>;
 supports-highspeed;
 supports-emmc;
 bootpart-no-access;
 supports-DDR_MODE;
 ignore-pm-notify;
 keep-power-in-suspend;

 status = "okay";
};

&sdmmc {
 clock-frequency = <37500000>;
 clock-freq-min-max = <400000 37500000>;
 supports-highspeed;
 supports-sd;
 broken-cd;
 card-detect-delay = <200>;
 ignore-pm-notify;
 keep-power-in-suspend;
 vmmc-supply = <&rk818_ldo9_reg>;
 status = "disabled";
};

&sdio {
 clock-frequency = <37500000>;
 clock-freq-min-max = <200000 37500000>;
 supports-highspeed;
 supports-sdio;
 ignore-pm-notify;
 keep-power-in-suspend;
 cap-sdio-irq;
 status = "okay";
};

&adc {
 status = "okay";

 key: key {
  compatible = "rockchip,key";
  io-channels = <&adc 1>;

  vol-up-key {
   linux,code = <115>;
   label = "volume up";
   rockchip,adc_value = <523>;
  };

  vol-down-key {
   linux,code = <114>;
   label = "volume down";
   rockchip,adc_value = <727>;
  };

  power-key {
   gpios = <&gpio0 5 1>;
   linux,code = <116>;
   label = "power";
   gpio-key,wakeup;
  };

  menu-key {
   linux,code = <59>;
   label = "menu";
   rockchip,adc_value = <1>;
  };

  home-key {
   linux,code = <102>;
   label = "home";
   rockchip,adc_value = <318>;
  };

  back-key {
   linux,code = <158>;
   label = "back";
   rockchip,adc_value = <146>;
  };

  camera-key {
   linux,code = <212>;
   label = "camera";
   rockchip,adc_value = <450>;
  };
 };
};


&i2c0 {
 status = "okay";
 rk818: rk818@1c {
  reg = <0x1c>;
  status = "okay";
 };
 act8931: act8931@5b {
  reg = <0x5b>;
  status = "okay";
 };
 rt5025: rt5025@35 {
   compatible = "rt,rt5025";
   reg = <0x35>;
   status = "disabled";
 };
 rt5036: rt5036@38 {
   compatible = "rt,rt5036";
   reg = <0x38>;
   status = "disabled";
 };
};

&i2c2 {
 status = "okay";
 ts@55 {
  compatible = "goodix,gt8xx";
  reg = <0x55>;
  touch-gpio = <&gpio1 8 8>;
  reset-gpio = <&gpio2 17 1>;

  max-x = <1280>;
  max-y = <800>;
 };
# 204 "arch/arm/boot/dts/rk312x-sdk.dtsi"
};

&fb {
 rockchip,disp-mode = <1>;
 rockchip,uboot-logo-on = <0>;
};


/include/ "rt5025.dtsi"
&rt5025 {

   rt5025_dcdc1: regulator_0 {
    regulator-name = "vdd_arm";
    regulator-min-microvolt = < 700000>;
    regulator-max-microvolt = <1500000>;
    qcom,comsumer-supplies = "vdd_arm", "";
    regulator-always-on;
    regulator-boot-on;

   };

   rt5025_dcdc2: regulator_1 {
    regulator-name = "vdd_logic";
    regulator-min-microvolt = < 700000>;
    regulator-max-microvolt = <1500000>;
    qcom,comsumer-supplies = "vdd_logic", "";
    regulator-always-on;
    regulator-boot-on;
   };

   rt5025_dcdc3: regulator_2 {
    regulator-name = "rt5025-dcdc3";
    regulator-min-microvolt = < 1800000>;
    regulator-max-microvolt = <3300000>;
    qcom,comsumer-supplies = "rt5025-dcdc3", "";
    regulator-always-on;
    regulator-boot-on;
   };

   rt5025_dcdc4: regulator_3 {
    regulator-name = "rt5025-dcdc4";
    regulator-min-microvolt = <5000000>;
    regulator-max-microvolt = <5000000>;
    qcom,comsumer-supplies = "rt5025-dcdc4", "";
    regulator-always-on;
    regulator-boot-on;
   };

   rt5025_ldo1: regulator_4 {
    regulator-name = "rt5025-ldo1";
    regulator-min-microvolt = < 1800000>;
    regulator-max-microvolt = <1800000>;
    qcom,comsumer-supplies = "rt5025-ldo1", "";
    regulator-always-on;
    regulator-boot-on;
   };

   rt5025_ldo2: regulator_5 {
    regulator-name = "rt5025-ldo2";
    regulator-min-microvolt = < 1200000>;
    regulator-max-microvolt = <1200000>;
    qcom,comsumer-supplies = "rt5025-ldo2", "";
    regulator-always-on;
    regulator-boot-on;
   };

   rt5025_ldo3: regulator_6 {
    regulator-name = "rt5025-ldo3";
    regulator-min-microvolt = <2800000>;
    regulator-max-microvolt = <2800000>;
    qcom,comsumer-supplies = "rt5025-ldo3", "";
    regulator-always-on;
    regulator-boot-on;
   };

   rt5025_ldo4: regulator_7 {
    regulator-name = "rt5025-ldo4";
    regulator-min-microvolt = <3300000>;
    regulator-max-microvolt = <3300000>;
    qcom,comsumer-supplies = "rt5025-ldo4", "";
    regulator-always-on;
    regulator-boot-on;
   };

   rt5025_ldo5: regulator_8 {
    regulator-name = "rt5025-ldo5";
    regulator-min-microvolt = <1800000>;
    regulator-max-microvolt = <1800000>;
    qcom,comsumer-supplies = "rt5025-ldo5", "";
    regulator-always-on;
    regulator-boot-on;
   };

   rt5025_ldo6: regulator_9 {
    regulator-name = "rt5025-ldo6";
    regulator-min-microvolt = <330000>;
    regulator-max-microvolt = <3300000>;
    qcom,comsumer-supplies = "rt5025-ldo6", "";
    regulator-always-on;
    regulator-boot-on;
   };

 rt5025-irq {
    compatible = "rt,rt5025-irq";
    rt,irq-gpio = <&gpio1 9 0>;
 };
};

/include/ "rt5036.dtsi"
&rt5036 {

   rt5036_dcdc1: regulator_0 {
    regulator-name = "vdd_arm";
    regulator-min-microvolt = < 800000>;
    regulator-max-microvolt = <3300000>;
    qcom,comsumer-supplies = "vdd_arm", "";
    regulator-always-on;
    regulator-boot-on;
    rt,standby_enabled;
    rt,standby_vol = <950000>;
   };

   rt5036_dcdc2: regulator_1 {
    regulator-name = "vdd_logic";
    regulator-min-microvolt = < 800000>;
    regulator-max-microvolt = <3300000>;
    qcom,comsumer-supplies = "vdd_logic", "";
    regulator-always-on;
    regulator-boot-on;
    rt,standby_enabled;
    rt,standby_vol = <950000>;
   };

   rt5036_dcdc3: regulator_2 {
    regulator-name = "rt5036-dcdc3";
    regulator-min-microvolt = < 800000>;
    regulator-max-microvolt = <3300000>;
    qcom,comsumer-supplies = "rt5036-dcdc3", "";
    regulator-always-on;
    regulator-boot-on;
    rt,standby_enabled;
    rt,standby_vol = <2800000>;
   };

   rt5036_dcdc4: regulator_3 {
    regulator-name = "rt5036-dcdc4";
    regulator-min-microvolt = < 800000>;
    regulator-max-microvolt = <3300000>;
    qcom,comsumer-supplies = "rt5036-dcdc4", "";
    regulator-always-on;
    regulator-boot-on;
    rt,standby_enabled;
    rt,standby_vol = <1200000>;
   };

   rt5036_ldo1: regulator_4 {
    regulator-name = "rt5036-ldo1";
    regulator-min-microvolt = <1200000>;
    regulator-max-microvolt = <1200000>;
    qcom,comsumer-supplies = "rt5036-ldo1", "";
    regulator-always-on;
    regulator-boot-on;
    rt,standby_enabled;
    rt,standby_vol = <1200000>;
   };

   rt5036_ldo2: regulator_5 {
    regulator-name = "rt5036-ldo2";
    regulator-min-microvolt = < 1100000>;
    regulator-max-microvolt = <1100000>;
    qcom,comsumer-supplies = "rt5036-ldo2", "";
    regulator-always-on;
    regulator-boot-on;
    rt,standby_enabled;
    rt,standby_vol = <1100000>;
   };

   rt5036_ldo3: regulator_6 {
    regulator-name = "rt5036-ldo3";
    regulator-min-microvolt = < 1800000>;
    regulator-max-microvolt = <1800000>;
    qcom,comsumer-supplies = "rt5036-ldo3", "";
    regulator-always-on;
    regulator-boot-on;
    rt,standby_enabled;
    rt,standby_vol = <1800000>;
   };

   rt5036_ldo4: regulator_7 {
    regulator-name = "rt5036-ldo4";
    regulator-min-microvolt = < 1800000>;
    regulator-max-microvolt = <1800000>;
    qcom,comsumer-supplies = "rt5036-ldo4", "";
    regulator-always-on;
    regulator-boot-on;
    rt,standby_enabled;
    rt,standby_vol = <1800000>;
   };

   rt5036_ldo5: regulator_8 {
    regulator-name = "rt5036-ldo5";
    qcom,comsumer-supplies = "rt5036-ldo5", "";
    regulator-always-on;
    regulator-boot-on;
    rt,standby_enabled;
   };

   rt5036_ldo6: regulator_9 {
    regulator-name = "rt5036-ldo6";
    qcom,comsumer-supplies = "rt5036-ldo6", "";
    regulator-always-on;
    regulator-boot-on;
    rt,standby_enabled;
   };

   rt5036-irq {
    compatible = "rt,rt5036-irq";
    rt,irq-gpio = <&gpio1 9 0>;
   };

   rt5036-charger {
    compatible = "rt,rt5036-charger";
    rt,te_en;
    rt,iprec = <0x2>;
    rt,ieoc = <0x3>;
    rt,vprec = <0xA>;
    rt,batlv = <0x4>;
    rt,vrechg = <1>;
    rt,chg_volt = <4200>;
    rt,otg_volt = <5025>;
    rt,acchg_icc = <2000>;
    rt,usbtachg_icc = <2000>;
    rt,usbchg_icc = <900>;


   };
};

/include/ "rk818.dtsi"
&rk818 {
 gpios =<&gpio3 22 0>,<&gpio3 17 1>;
 cpu_det_gpio = <&gpio0 25 0>;
 power_hold_gpio = <&gpio2 5 0>;
 power_hold_gpio-v01 = <&gpio2 0 0>;
 rk818,system-power-controller;
 rk818,support_dc_chg = <1>;

 regulators {

  rk818_dcdc1_reg: regulator@0{
   regulator-name= "vdd_arm";
   regulator-min-microvolt = <700000>;
   regulator-max-microvolt = <1500000>;
   regulator-initial-mode = <0x2>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-mode = <0x2>;
    regulator-state-disabled;
    regulator-state-uv = <900000>;
   };
  };

  rk818_dcdc2_reg: regulator@1 {
   regulator-name= "vdd_logic";
   regulator-min-microvolt = <700000>;
   regulator-max-microvolt = <1500000>;
   regulator-initial-mode = <0x2>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-mode = <0x2>;
    regulator-state-enabled;
    regulator-state-uv = <900000>;
   };
  };

  rk818_dcdc3_reg: regulator@2 {
   regulator-name= "rk818_dcdc3";
   regulator-min-microvolt = <1200000>;
   regulator-max-microvolt = <1200000>;
   regulator-initial-mode = <0x2>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-mode = <0x2>;
    regulator-state-enabled;
    regulator-state-uv = <1200000>;
   };
  };

  rk818_dcdc4_reg: regulator@3 {
   regulator-name= "vccio";
   regulator-min-microvolt = <1800000>;
   regulator-max-microvolt = <3300000>;
   regulator-initial-mode = <0x2>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-mode = <0x2>;
    regulator-state-enabled;
    regulator-state-uv = <2800000>;
   };
  };

  rk818_ldo1_reg: regulator@4 {
   regulator-name= "rk818_ldo1";
   regulator-min-microvolt = <3300000>;
   regulator-max-microvolt = <3300000>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-enabled;
    regulator-state-uv = <3300000>;
   };
  };

  rk818_ldo2_reg: regulator@5 {
   regulator-name= "rk818_ldo2";
   regulator-min-microvolt = <3000000>;
   regulator-max-microvolt = <3000000>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-enabled;
    regulator-state-uv = <3000000>;
   };
  };

  rk818_ldo3_reg: regulator@6 {
   regulator-name= "rk818_ldo3";
   regulator-min-microvolt = <1100000>;
   regulator-max-microvolt = <1100000>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-enabled;
    regulator-state-uv = <1100000>;
   };
  };

  rk818_ldo4_reg:regulator@7 {
   regulator-name= "rk818_ldo4";
   regulator-min-microvolt = <2800000>;
   regulator-max-microvolt = <2800000>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-enabled;
    regulator-state-uv = <2500000>;
   };
  };

  rk818_ldo5_reg: regulator@8 {
   regulator-name= "rk818_ldo5";
   regulator-min-microvolt = <3000000>;
   regulator-max-microvolt = <3000000>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-enabled;
    regulator-state-uv = <3000000>;
   };
  };

  rk818_ldo6_reg: regulator@9 {
   regulator-name= "rk818_ldo6";
   regulator-min-microvolt = <1200000>;
   regulator-max-microvolt = <1200000>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-enabled;
    regulator-state-uv = <1200000>;
   };
  };

  rk818_ldo7_reg: regulator@10 {
   regulator-name= "rk818_ldo7";
   regulator-min-microvolt = <1800000>;
   regulator-max-microvolt = <1800000>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-enabled;
    regulator-state-uv = <1800000>;
   };
  };

  rk818_ldo8_reg: regulator@11 {
   regulator-name= "rk818_ldo8";
   regulator-min-microvolt = <1800000>;
   regulator-max-microvolt = <1800000>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-enabled;
    regulator-state-uv = <1800000>;
   };
  };
  rk818_ldo9_reg: regulator@12 {
   regulator-name= "vcc_sd";
   regulator-min-microvolt = <1800000>;
   regulator-max-microvolt = <3000000>;
   regulator-initial-state = <3>;
   regulator-state-mem {
    regulator-state-enabled;
    regulator-state-uv = <3000000>;
   };
  };
  rk818_ldo10_reg: regulator@13 {
   regulator-name= "rk818_ldo10";
   regulator-state-mem {
    regulator-state-disabled;
   };
  };
 };
 battery {
                ocv_table = <3350 3677 3693 3719 3752 3770 3775 3778 3785 3796 3812 3839 3881 3907 3933 3958 3978 4033 4087 4123 4174>;
                design_capacity = <2100>;
                design_qmax = <2200>;
                max_overcharge = <100>;
                bat_res = <80>;
                max_input_currentmA = <2000>;
                max_chrg_currentmA = <1800>;
                max_charge_voltagemV = <4200>;
                max_bat_voltagemV = <4200>;
                sleep_enter_current = <300>;
                sleep_exit_current = <300>;
                power_off_thresd = <3400>;
                chrg_diff_voltagemV = <0>;
                virtual_power = <0>;
                support_usb_adp = <1>;
                support_dc_adp = <0>;
                power_dc2otg = <0>;
        };

};

/include/ "act8931.dtsi"
&act8931 {

 gpios = <&gpio2 9 0>, <&gpio1 2 0>;
 act8931,system-power-controller;

 regulators {

  act8931_dcdc1_reg: regulator@0{
   regulator-name= "vccio";
   regulator-min-microvolt = <1800000>;
   regulator-max-microvolt = <3300000>;
   regulator-initial-mode = <0x2>;
  };

  act8931_dcdc2_reg: regulator@1 {
   regulator-name= "act_dcdc2";
   regulator-min-microvolt = <1500000>;
   regulator-max-microvolt = <1500000>;
   regulator-initial-mode = <0x2>;
  };

  act8931_dcdc3_reg: regulator@2 {
   regulator-name= "vdd_arm";
   regulator-min-microvolt = <700000>;
   regulator-max-microvolt = <1500000>;
   regulator-initial-mode = <0x2>;
  };

  act8931_ldo1_reg:regulator@3 {
   regulator-name= "act_ldo1";
   regulator-min-microvolt = <2800000>;
   regulator-max-microvolt = <2800000>;
  };

  act8931_ldo2_reg: regulator@4 {
   regulator-name= "act_ldo2";
   regulator-min-microvolt = <1800000>;
   regulator-max-microvolt = <1800000>;
  };

  act8931_ldo3_reg: regulator@5 {
   regulator-name= "act_ldo3";
   regulator-min-microvolt = <3300000>;
   regulator-max-microvolt = <3300000>;
  };

  act8931_ldo4_reg: regulator@6 {
   regulator-name= "act_ldo4";
   regulator-min-microvolt = <3300000>;
   regulator-max-microvolt = <3300000>;
  };
 };

};

&pwm0 {
        status = "okay";
};
# 6 "arch/arm/boot/dts/rk3128-fireprime.dts" 2
# 1 "arch/arm/boot/dts/lcd-box.dtsi" 1





/ {
   disp_power_ctr: power_ctr {
# 32 "arch/arm/boot/dts/lcd-box.dtsi"
                };

  disp_timings: display-timings {
   native-mode = <&timing0>;
   timing0: timing0 {
    screen-type = <6>;
    out-face = <0>;
    color-mode = <1>;
    clock-frequency = <74250000>;
    hactive = <1280>;
    vactive = <720>;
    hback-porch = <220>;
    hfront-porch = <110>;
    vback-porch = <20>;
    vfront-porch = <5>;
    hsync-len = <40>;
    vsync-len = <5>;
    hsync-active = <1>;
    vsync-active = <1>;
    de-active = <0>;
    pixelclk-active = <0>;
    swap-rb = <0>;
    swap-rg = <0>;
    swap-gb = <0>;
                      };
                      timing1: timing1 {
    screen-type = <6>;
    out-face = <0>;
    color-mode = <1>;
    clock-frequency = <148500000>;
    hactive = <1920>;
    vactive = <1080>;
    hback-porch = <148>;
    hfront-porch = <88>;
    vback-porch = <36>;
    vfront-porch = <4>;
    hsync-len = <44>;
    vsync-len = <5>;
    hsync-active = <1>;
    vsync-active = <1>;
    de-active = <0>;
    pixelclk-active = <0>;
    swap-rb = <0>;
    swap-rg = <0>;
    swap-gb = <0>;
                      };
                      timing2: timing2 {
    screen-type = <6>;
    out-face = <0>;
    color-mode = <1>;
    clock-frequency = <297000000>;
    hactive = <3840>;
    vactive = <2160>;
    hback-porch = <296>;
    hfront-porch = <176>;
    vback-porch = <72>;
    vfront-porch = <8>;
    hsync-len = <88>;
    vsync-len = <10>;
    hsync-active = <1>;
    vsync-active = <1>;
    de-active = <0>;
    pixelclk-active = <0>;
    swap-rb = <0>;
    swap-rg = <0>;
    swap-gb = <0>;
                      };
               };
};
# 7 "arch/arm/boot/dts/rk3128-fireprime.dts" 2
# 1 "/opt/RK3128/rk3128/fireprime-kernel/arch/arm/boot/dts/include/dt-bindings/input/input.h" 1
# 8 "arch/arm/boot/dts/rk3128-fireprime.dts" 2

/ {
  compatible = "rockchip,rk3128";
# 20 "arch/arm/boot/dts/rk3128-fireprime.dts"
        wireless-wlan {
                compatible = "wlan-platdata";







                wifi_chip_type = "ap6212a";
                sdio_vref = <3300>;



                power_pmu_regulator = "vccio";
                power_pmu_enable_level = <1>;






                WIFI,poweren_gpio = <&gpio3 21 0>;
                WIFI,host_wake_irq = <&gpio0 2 0>;


                status = "okay";
        };

                wireless-bluetooth {
                compatible = "bluetooth-platdata";



                uart_rts_gpios = <&gpio0 17 1>;
                pinctrl-names = "default","rts_gpio";
                pinctrl-0 = <&uart0_rts>;
                pinctrl-1 = <&uart0_rts_gpio>;


                BT,reset_gpio = <&gpio1 3 0>;
                BT,wake_gpio = <&gpio3 26 0>;
                BT,wake_host_irq = <&gpio3 27 1>;

        status = "okay";
    };

       leds {
       compatible = "gpio-leds";
       power {
           label = "firefly:blue:power";
           linux,default-trigger = "ir-power-click";
           default-state = "on";
           gpios = <&gpio1 23 1>;
       };
        user {
           label = "firefly:yellow:user";
           linux,default-trigger = "ir-user-click";
           default-state = "off";
     gpios = <&gpio1 22 1>;
           gpios-v01 = <&gpio2 3 1>;
           };
        };

        rockchip-spdif-card {
                compatible = "rockchip-spdif-card";
                dais {
                        dai0 {
                                audio-codec = <&codec_hdmi_spdif>;
                                audio-controller = <&spdif>;
                        };
                };
        };

 usb_control {
  compatible = "rockchip,rk3126-usb-control";

  host_drv_gpio = <&gpio0 30 1>;
  otg_drv_gpio = <&gpio0 8 1>;

  rockchip,remote_wakeup;
  rockchip,usb_irq_wakeup;
 };
        rockchip_suspend {
               rockchip,ctrbits = <
                       (0
                       |(1 << (0))
                       |(1 << (1))
                       |(1 << (2))

                       |(1 << (5))
                       |(1 << (16))
                       |(1 << (5))




                       )
               >;
               rockchip,pmic-suspend_gpios = <0x3c10>;
        };

test-power {
        status = "okay";
};
};

&i2c0 {
        status = "okay";
        rtc@51 {
                compatible = "rtc,hym8563";
                reg = <0x51>;
                irq_gpio = <&gpio0 28 2>;
        };
  ts@41 {
   compatible = "tchip,gsl3680";
   reg = <0x41>;
   touch-gpio = <&gpio1 12 1>;

   max-x = <1280>;
   max-y = <800>;
  };
};

&fb {
       rockchip,disp-mode = <0>;
       rockchip,disp-policy = <1>;
       rockchip,uboot-logo-on = <1>;
};

&disp_timings {
        native-mode = <&timing0>;
};

&rk_screen {
 display-timings = <&disp_timings>;
};

&lvds {
 status = "okay";

 pinctrl-names = "lcdc";
 pinctrl-0 = <&lcdc0_lcdc_d>;
};

&lcdc {
 status = "okay";
        rockchip,fb-win-map = <210>;
};

&hdmi {
        status = "okay";
 rockchip,hdmi_audio_source = <1>;
};
&tve {
        status = "okay";
        test_mode = <0>;
};

&uart0 {
        status = "okay";
 clock-frequency = "<24000000>";
        dma-names = "!tx", "!rx";
        pinctrl-0 = <&uart0_xfer &uart0_cts>;
};
&uart1 {
 status = "okay";
};

&sdmmc {
 status = "okay";
 cd-gpios = <&gpio1 17 0>;
};
&key {
  power-key {
   gpios = <&gpio3 23 1>;
   linux,code = <116>;
   label = "power";
   gpio-key,wakeup;
  };
                recovery-key {
                        linux,code = <113>;
                        label = "recovery";
                        rockchip,adc_value = <4>;
                };
};

&dwc_control_usb {
 usb_uart {
  status = "disabled";
 };
};
&codec {


        spk-mute-delay = <200>;
        hp-mute-delay = <100>;
        rk312x_for_mid = <0>;
        is_rk3128 = <0>;
        spk_volume = <100>;
        hp_volume = <100>;
        capture_volume = <26>;
        gpio_debug = <1>;
        codec_hp_det = <0>;
};

&rk3128_cif_sensor{
 status = "okay";
};

&i2c2 {
 status = "disabled";
};

&gmac_clkin {
        clock-frequency = <125000000>;
};

&gmac {



        reset-gpio = <&gpio2 24 1>;
        phyirq-gpio = <&gpio0 24 1>;
        phy-mode = "rgmii";
        clock_in_out = "input";
        tx_delay = <0x30>;
        rx_delay = <0x10>;
};

&pwm0 {
        status = "okay";
};
&pwm1 {
        status = "okay";
};
&pwm2 {
        status = "okay";
};

&clk_core_dvfs_table {
 operating-points = <

  216000 925000
  408000 925000
  600000 950000
  696000 975000
  816000 1050000
  1008000 1175000
  1200000 1300000
  1296000 1350000
  1320000 1375000
  >;
 virt-temp-limit-1-cpu-busy = <

  75 1008000
  85 1200000
  95 1200000
  100 1200000
  >;
 virt-temp-limit-2-cpu-busy = <

  75 912000
  85 1008000
  95 1104000
  100 1200000
  >;
 virt-temp-limit-3-cpu-busy = <

  75 816000
  85 912000
  95 100800
  100 110400
  >;
 virt-temp-limit-4-cpu-busy = <

  75 816000
  85 912000
  95 100800
  100 110400
  >;
 temp-limit-enable = <1>;
 target-temp = <85>;
 status="okay";
};

&clk_gpu_dvfs_table {
 operating-points = <

  200000 950000
  300000 975000
  400000 1075000

  >;
 status="okay";
};

&clk_ddr_dvfs_table {
 operating-points = <

  200000 1250000
  300000 1250000
  400000 1250000
  >;

 operating-points-v01 = <

  200000 950000
  300000 950000
  400000 1200000
  533000 1250000
  >;

 freq-table = <

  (1<<0) 500000
  (1<<1) 200000
  (1<<5) 240000
  (1<<4) 400000
  (1<<13) 528000
  ((1<<10)|(1<<11)) 400000
  (1<<12) 324000
  (1<<14) 533000
  >;
 auto-freq-table = <
  240000
  324000
  396000
  528000
  >;
 auto-freq=<0>;
 status="okay";
};

&remotectl {
        handle_cpu_id = <2>;
        ir_key1{
                rockchip,usercode = <0xff00>;
                rockchip,key_table =
                       <0xeb 116>,
                       <0xa3 250>,
                       <0xec 139>,
                       <0xfc 103>,
                       <0xfd 108>,
                       <0xf1 105>,
                       <0xe5 106>,
                       <0xf8 232>,
                       <0xb7 102>,
                       <0xfe 158>,
                       <0xa7 114>,
                       <0xf4 115>;
        };
};
